**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************

.SUBCKT BAV70LT1G 1 2
*
* The resistor R1 does not reflect
* a physical device.  Instead it
* improves modeling in the reverse
* mode of operation.
*
R1 1 2 2.3E+9
D1 1 2 bav70lt1g

* Model generated on 10/18/07
* MODEL FORMAT: SPICE3
.MODEL bav70lt1g d
+IS=7.85162e-09 RS=1.24107 N=1.93575 EG=1.1965
+XTI=0.5 BV=1000 IBV=0.0001 CJO=9.14173e-13
+VJ=2.14855 M=0.2 FC=0.5 TT=1e-09
+KF=0 AF=1
.ENDS

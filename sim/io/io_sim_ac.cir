* gnetlist -g spice-sdb -o io_sim_ac.cir io_sim_ac.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*vvvvvvvv  Included SPICE model from PFET_60V.lib vvvvvvvv
*****************************************************************
* INFINEON Power Transistors                                    *
* Level-1 / 3 PSPICE Library for PFET p-Channel Transistors     *
* Version 280208                                                *
*                                                               *
*****************************************************************
*                                                               *
* Models provided by Infineon are not warranted by Infineon as  *
* fully representing all the specifications and operating       *
* characteristics of the semiconductor product to which the     *
* model relates. The models describe the characteristics of     *
* typical devices.                                              *
* In all cases, the current data sheet information for a given  *
* device is the final design guideline and the only actual      *
* performance specification.                                    *
* Although models can be a useful tool in evaluating device     *
* performance, they cannot model exact device performance under *
* all conditions, nor are they intended to replace bread-       *
* boarding for final verification. INFINEON therefore does not  *
* assume any liability arising from their use.                  *
* INFINEON reserves the right to change models without prior    *
* notice.                                                       *
*                                                               *
* This library contains models of the following INFINEON        *
* p-channel transistors:                                        *
*                                                               *
*        -60 V logic level           -60 V normal level         *
*                                                               *
*            SPD09P06PL                  SPB08P06P              *
*            SPU09P06PL                  SPD08P06P              *
*            BSP315P                     SPP08P06P              *
*            BSP171P                     SPU08P06P              *
*            BSS83P                      BSP170P                *
*            BSS84P                      SPB18P06P              *
*            BSS84PW                     SPD18P06P              *
*            SISC0_25P06P                SPP18P06P              *
*            BSR315P                     SPU18P06P              *
*                                        BSP613P                *
*                                        BSO613SPV              *
*                                        SPD30P06P              *
*                                        SPU30P06P              *
*                                        SPB80P06P              *
*                                        SPP80P06P              *
*****************************************************************
*****************************************************************
* thermal nodes of level 3 models:                              *
*                                                               *
*  .SUBCKT SPU09P06PL drain gate source Tj Tcase                *
*  Tj :    potential=temperature (in ?C) at junction (typically *
*          not connected)                                       *
*  Tcase : node where the boundary contition - external heat    *
*          sinks etc - have to be connected (ideal heat sink    *
*          can be modeled by using a voltage source stating the *
*          ambient temperature in ?C between Tcase and ground.  *
*                                                               *
*****************************************************************

*$
.SUBCKT P_60_l_var dd g s Tj PARAMS: a=2.32 dVth=0 dR=0 dgfs=0 Inn=3.5 Unn=10 Rmax=67m gmin=1 Rs=1m dC=0 heat=0

.PARAM  kbq=85.8u    Tref=298      T0=273
.PARAM  nsub=5.4     N=1.5         Vth0= 2.1   dib=5m        auth = 1.75m
.PARAM  c=0.65       nmu=1.5       ndi= 1.5    UBr = 70
.PARAM  aubr=60m     UTnbr=0.05    lnIb=-8.3   beta=1.8      lnIsj = -19.5
.PARAM  Rd=365m      ta=30n        td=30n      Rdi=40m
.PARAM  Cgs0=140p    Cds0=139p     Cox0=250p   U0=1.03       Vn=0.15

.PARAM  Vmin=1.6     Vmax=2.6      gfmin=0.5   dCmax=0.33

.PARAM  Vth={Vth0+(Vmax-Vth0)*limit(dVth,0,1)-(Vmin-Vth0)*limit(dVth,-1,0)}
.PARAM  p1={(Unn-Inn*Rs-Vth)*beta*a}
.PARAM  p2={(dib-c)*Inn*beta*a}
.PARAM  Rlim={(p1+2*p2*Rmax-SQRT(p1**2+4*p2))/(2*p2)}
.PARAM  dRd={Rd/a+if(dVth==0,limit(dR,0,1)*max(Rlim-Rd/a-Rs,0),0)}
.PARAM  bm={c/((1/gmin-Rs)**2*Inn*a*(T0/Tref)**nmu)}
.PARAM  bet={(beta+(beta-bm)*if(dR==0,if(dVth==0,limit(dgfs,-1,0),0),0))}

.PARAM  dC1={1+dCmax*limit(dC,0,1)}
.PARAM  dC2={1+1.5*dCmax*limit(dC,0,1)}

.PARAM  Cgs={Cgs0*dC1}
.PARAM  Cox={Cox0*dC2}
.PARAM  Cds={Cds0*dC1}

*MOS+Diode
.FUNC I0(Uds,Uee,ph,ps)  {if(Uee>ps,(Uee-c*min(Uds,Uee/(2*c)))*min(Uds,Uee/(2*c)),ph*(ps-ph)/c*exp((Uee-ps)/ph))}
.FUNC Imos(Uds,Ugs,T,ph) {bet/((T/Tref)**n)*I0(Uds,Ugs-Vth+dib*Uds+auth*(T-Tref),ph,min(2*ph,ph+c*Uds))}
.FUNC Iges(Uds,Ugs,T)    {a*sgn(Uds)*(Imos(abs(Uds),Ugs,T,nsub*kbq*T)+exp(min(lnIb+(Uds-Ubr-aubr*(T-Tref))/UTnbr,7)))}
.FUNC Isjt(T)            {exp(min(lnIsj+(T/Tref-1)*1.12/(ndi*kbq*T),7))*T/Tref}
.FUNC Idiode(Usd,T,Iss)  {exp(min(log(Iss)+Usd/(ndi*kbq*T),7))-Iss}

E_Edg  d1 ox VALUE {-max(-V(d1,g),0)+2*Vn*SQRT(1+max(-V(d1,g),0)/Vn)}
C_Cdg  ox g {Cox*a+5p}
E_Eds  d1 edep VALUE {V(d1,s)+2*(SQRT(U0*max(U0-V(d1,s),0))-U0)}
C_Cds  edep s {Cds*a}
C_Cgs  g  s {Cgs*a+5p}

G_G1 s d1 VALUE={Iges(V(s,d1),V(s,g),T0+limit(V(Tj),-200,999))+LIMIT(I(V_sense3),-1k,1k)}
G_drain d1 d2 VALUE={V(d1,d2)/(dRd*((limit(V(Tj),-200,999)+T0)/Tref)**nmu)}
V_sense d2 dd 0
G_diode d3 s VALUE={a*Idiode(V(d3,s),T0+limit(V(Tj),-200,999),Isjt(T0+limit(V(Tj),-200,999)))}
R_diode d3 d4 {Rdi/a}
V_sense2 d2 d4 0

C_C001    a   0 {ta*td/(ta+td)}
R_R001    a   b 1
V_sense3  b   c 0
E_E001    c   0 VALUE {ta/td*I(V_sense2)}

R1 g s 2G
Rd01 d1 s   500Meg
Rd02 d1 d2  1k

G_TH 0 Tj VALUE = {heat*LIMIT(I(V_sense)*V(s,dd),0,100k)}

.ENDS
*$

*****************************************************************

.SUBCKT P_60_n_var dd g s Tj PARAMS: a=2.32 dVth=0.1 dR=0 dgfs=0 Inn=3.5 Unn=4.5 Rmax=67m gmin=10 Rs=17.5m dC=0 heat=0

.PARAM  kbq=85.8u    Tref=298      T0=273
.PARAM  nsub=7.36    N=1.5         Vth0= 3.0   dib=5m        auth = 1.75m
.PARAM  c=0.65       nmu=1.5       ndi= 1.5    UBr = 70
.PARAM  aubr=60m     UTnbr=0.05    lnIb=-8.3   beta=1.24     lnIsj = -19.5
.PARAM  Rd=365m      ta=30n        td=30n      Rdi=40m
.PARAM  Cgs0=120p    Cds0=139p     Cox0=180p   U0=1.03       Vn=0.35

.PARAM  Vmin=2.1     Vmax=4        gfmin=0.5   dCmax=0.33

.PARAM  Vth={Vth0+(Vmax-Vth0)*limit(dVth,0,1)-(Vmin-Vth0)*limit(dVth,-1,0)}
.PARAM  p1={(Unn-Inn*Rs-Vth)*beta*a}
.PARAM  p2={(dib-c)*Inn*beta*a}
.PARAM  Rlim={(p1+2*p2*Rmax-SQRT(p1**2+4*p2))/(2*p2)}
.PARAM  dRd={Rd/a+if(dVth==0,limit(dR,0,1)*max(Rlim-Rd/a-Rs,0),0)}
.PARAM  bm={c/((1/gmin-Rs)**2*Inn*a*(T0/Tref)**nmu)}
.PARAM  bet={(beta+(beta-bm)*if(dR==0,if(dVth==0,limit(dgfs,-1,0),0),0))}
.PARAM  dC1={1+dCmax*limit(dC,0,1)}
.PARAM  dC2={1+1.5*dCmax*limit(dC,0,1)}

.PARAM  Cgs={Cgs0*dC1}
.PARAM  Cox={Cox0*dC2}
.PARAM  Cds={Cds0*dC1}

*MOS+Diode
.FUNC I0(Uds,Uee,ph,ps)  {if(Uee>ps,(Uee-c*min(Uds,Uee/(2*c)))*min(Uds,Uee/(2*c)),ph*(ps-ph)/c*exp((Uee-ps)/ph))}
.FUNC Imos(Uds,Ugs,T,ph) {bet/((T/Tref)**n)*I0(Uds,Ugs-Vth+dib*Uds+auth*(T-Tref),ph,min(2*ph,ph+c*Uds))}
.FUNC Iges(Uds,Ugs,T)    {a*sgn(Uds)*(Imos(abs(Uds),Ugs,T,nsub*kbq*T)+exp(min(lnIb+(Uds-Ubr-aubr*(T-Tref))/UTnbr,7)))}
.FUNC Isjt(T)            {exp(min(lnIsj+(T/Tref-1)*1.12/(ndi*kbq*T),7))*T/Tref}
.FUNC Idiode(Usd,T,Iss)  {exp(min(log(Iss)+Usd/(ndi*kbq*T),7))-Iss}

E_Edg  d1 ox VALUE {-max(-V(d1,g),0)+2*Vn*SQRT(1+max(-V(d1,g),0)/Vn)}
C_Cdg  ox g {Cox*a+5p}
E_Eds  d1 edep VALUE {V(d1,s)+2*(SQRT(U0*max(U0-V(d1,s),0))-U0)}
C_Cds  edep s {Cds*a}
C_Cgs  g  s {Cgs*a}

G_G1 s d1 VALUE={Iges(V(s,d1),V(s,g),T0+limit(V(Tj),-200,999))+LIMIT(I(V_sense3),-1k,1k)}
G_drain d1 d2 VALUE={V(d1,d2)/(dRd*((limit(V(Tj),-200,999)+T0)/Tref)**nmu)}
V_sense d2 dd 0
G_diode d3 s VALUE={a*Idiode(V(d3,s),T0+limit(V(Tj),-200,999),Isjt(T0+limit(V(Tj),-200,999)))}
R_diode d3 d4 {Rdi/a}
V_sense2 d2 d4 0

C_C001    a   0 {ta*td/(ta+td)}
R_R001    a   b 1
V_sense3  b   c 0
E_E001    c   0 VALUE {ta/td*I(V_sense2)}

R1 g s 2G
Rd01 d1 s   500Meg
Rd02 d1 d2  1k

G_TH 0 Tj VALUE = {heat*LIMIT(I(V_sense)*V(s,dd),0,100k)}

.ENDS
*$

**********

.SUBCKT BSS83P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=76.19m    Rg=10        Rd=30m       Rm=2m
.PARAM Inn=0.33     Unn=10       Rmax=2       gmin=264.82m
.PARAM RRf=500m     Rrbond=489   Rtb=1k       g2=1000m
.PARAM act=0.32
.PARAM Ls=2n        Ld=1n        Lg=2n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               944.25n
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {85.67m+limit(dZth,0,1)*31.71m}
Rth2  t1      t2              {842.85m+limit(dZth,0,1)*311.92m}
Rth3  t2      t3              {1.81+limit(dZth,0,1)*1.41}
Rth4  t3      t4              {14.92+limit(dZth,0,1)*15.95}
Rth5  t4      Tcase           {55.4+limit(dZth,0,1)*59.24}
Cth1  Tj      0               3.21u
Cth2  t1      0               2.24u
Cth3  t2      0               18.1u
Cth4  t3      0               118.6u
Cth5  t4      0               894u
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT BSS84P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=75.39m    Rg=10        Rd=30m       Rm=1m
.PARAM Inn=0.17     Unn=10       Rmax=8       gmin=71.59m
.PARAM RRf=500m     Rrbond=489   Rtb=1k       g2=1000m
.PARAM act=0.0915
.PARAM Ls=2n        Ld=1n        Lg=2n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               944.25n
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {203.14m+limit(dZth,0,1)*75.18m}
Rth2  t1      t2              {2.8+limit(dZth,0,1)*1.04}
Rth3  t2      t3              {5.13+limit(dZth,0,1)*5.02}
Rth4  t3      t4              {8.9+limit(dZth,0,1)*19.37}
Rth5  t4      Tcase           {49.57+limit(dZth,0,1)*107.89}
Cth1  Tj      0               634n
Cth2  t1      0               782n
Cth3  t2      0               1.97u
Cth4  t3      0               30.6u
Cth5  t4      0               646u
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT BSS84PW drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=75.33m    Rg=10        Rd=50m       Rm=1m
.PARAM Inn=0.15     Unn=10       Rmax=8       gmin=80m
.PARAM RRf=500m     Rrbond=489   Rtb=1k       g2=1000m
.PARAM act=0.0915
.PARAM Ls=2n        Ld=1n        Lg=2n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               944.25n
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {383.57m+limit(dZth,0,1)*141.96m}
Rth2  t1      t2              {2.27+limit(dZth,0,1)*841.66m}
Rth3  t2      t3              {5.56+limit(dZth,0,1)*5.15}
Rth4  t3      t4              {8.34+limit(dZth,0,1)*4.1}
Rth5  t4      Tcase           {55.78+limit(dZth,0,1)*27.43}
Cth1  Tj      0               908n
Cth2  t1      0               1.24u
Cth3  t2      0               7.1u
Cth4  t3      0               36.2u
Cth5  t4      0               660u
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT BSP171P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=24.57m    Rg=10        Rd=2m        Rm=2m
.PARAM Inn=1.5      Unn=10       Rmax=0.3     gmin=1
.PARAM RRf=500m     Rrbond=44    Rtb=312.9    g2=1000m
.PARAM act=2.32
.PARAM Ls=3n        Ld=2n        Lg=2n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               10.14u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {13.37m+limit(dZth,0,1)*4.95m}
Rth2  t1      t2              {143.84m+limit(dZth,0,1)*53.23m}
Rth3  t2      t3              {1.2+limit(dZth,0,1)*186.76m}
Rth4  t3      t4              {3.28+limit(dZth,0,1)*3.87}
Rth5  t4      Tcase           {7.46+limit(dZth,0,1)*8.79}
Cth1  Tj      0               23.6u
Cth2  t1      0               21.7u
Cth3  t2      0               496u
Cth4  t3      0               805u
Cth5  t4      0               13.8m
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT BSO615C_p drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=9.62m     Rg=10        Rd=1m        Rm=2m
.PARAM Inn=2        Unn=10       Rmax=0.3     gmin=1.3
.PARAM RRf=500m     Rrbond=5     Rtb=100.4    g2=999m
.PARAM act=2.32
.PARAM Ls=3n        Ld=3n        Lg=3n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               21.95u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {13.37m+limit(dZth,0,1)*4.95m}
Rth2  t1      t2              {143.84m+limit(dZth,0,1)*53.23m}
Rth3  t2      t3              {3.93+limit(dZth,0,1)*186.76m}
Rth4  t3      t4              {20+limit(dZth,0,1)*0p}
Rth5  t4      Tcase           {22+limit(dZth,0,1)*0p}
Cth1  Tj      0               23.6u
Cth2  t1      0               21.7u
Cth3  t2      0               600u
Cth4  t3      0               805u
Cth5  t4      0               13.8m
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT SPD09P06PL drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=3.48m     Rg=10        Rd=50u       Rm=1m
.PARAM Inn=6.9      Unn=10       Rmax=0.25    gmin=2.03
.PARAM RRf=497m     Rrbond=884m  Rtb=46.3     g2=930m
.PARAM act=2.32
.PARAM Ls=3.5n      Ld=1n        Lg=6n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               487.73u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {13.45m+limit(dZth,0,1)*4.97m}
Rth2  t1      t2              {144.36m+limit(dZth,0,1)*53.42m}
Rth3  t2      t3              {553.29m+limit(dZth,0,1)*183.54m}
Rth4  t3      t4              {616.1m+limit(dZth,0,1)*872.22m}
Rth5  t4      Tcase           {479.63m+limit(dZth,0,1)*679.02m}
Cth1  Tj      0               28.2u
Cth2  t1      0               114.7u
Cth3  t2      0               588u
Cth4  t3      0               234u
Cth5  t4      0               24m
Cth6  Tcase   0               70m

.ENDS

**********

.SUBCKT SPU09P06PL drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=3.48m     Rg=10        Rd=350u      Rm=1m
.PARAM Inn=6.9      Unn=10       Rmax=0.25    gmin=2.03
.PARAM RRf=497m     Rrbond=884m  Rtb=46.3     g2=930m
.PARAM act=2.32
.PARAM Ls=3.5n      Ld=3n        Lg=6n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               487.73u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {13.45m+limit(dZth,0,1)*4.97m}
Rth2  t1      t2              {144.36m+limit(dZth,0,1)*53.42m}
Rth3  t2      t3              {553.29m+limit(dZth,0,1)*183.54m}
Rth4  t3      t4              {616.1m+limit(dZth,0,1)*872.22m}
Rth5  t4      Tcase           {479.63m+limit(dZth,0,1)*679.02m}
Cth1  Tj      0               28.2u
Cth2  t1      0               114.7u
Cth3  t2      0               588u
Cth4  t3      0               234u
Cth5  t4      0               24m
Cth6  Tcase   0               70m

.ENDS

**********

.SUBCKT BSP315P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=32.41m    Rg=10        Rd=2m        Rm=1m
.PARAM Inn=1.17     Unn=10       Rmax=0.8     gmin=799.93m
.PARAM RRf=500m     Rrbond=86    Rtb=434.6    g2=1000m
.PARAM act=0.8
.PARAM Ls=2n        Ld=1n        Lg=3n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               14.09u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {38.1m+limit(dZth,0,1)*14.11m}
Rth2  t1      t2              {507.22m+limit(dZth,0,1)*187.72m}
Rth3  t2      t3              {2.45+limit(dZth,0,1)*499.97m}
Rth4  t3      t4              {7.73+limit(dZth,0,1)*2.73}
Rth5  t4      Tcase           {8.01+limit(dZth,0,1)*2.83}
Cth1  Tj      0               7.99u
Cth2  t1      0               7.25u
Cth3  t2      0               168u
Cth4  t3      0               312u
Cth5  t4      0               14.1m
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT BSR315P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=63.27m    Rg=10        Rd=2m        Rm=1m
.PARAM Inn=0.62     Unn=10       Rmax=0.8     gmin=588.56m
.PARAM RRf=500m     Rrbond=343   Rtb=869.2    g2=1000m
.PARAM act=0.8
.PARAM Ls=2n        Ld=1n        Lg=3n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               7.04u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {36.96m+limit(dZth,0,1)*13.68m}
Rth2  t1      t2              {389.92m+limit(dZth,0,1)*144.31m}
Rth3  t2      t3              {2.17+limit(dZth,0,1)*544.37m}
Rth4  t3      t4              {42.8+limit(dZth,0,1)*37.24}
Rth5  t4      Tcase           {30.3+limit(dZth,0,1)*26.36}
Cth1  Tj      0               8.353u
Cth2  t1      0               32.557u
Cth3  t2      0               117.712u
Cth4  t3      0               1.17m
Cth5  t4      0               9.19m
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT SISC0_25P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=1.21m     Rg=10        Rd=1p        Rm=1m
.PARAM Inn=0.17     Unn=10       Rmax=8       gmin=71.63m
.PARAM RRf=486m     Rrbond=35u   Rtb=289.4m   g2=698m
.PARAM act=0.0915
.PARAM Ls=1p        Ld=1p        Lg=1p
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               48.77u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {203.14m+limit(dZth,0,1)*75.18m}
Rth2  t1      t2              {2.8+limit(dZth,0,1)*1.04}
Rth3  t2      t3              {7.82+limit(dZth,0,1)*5.02}
Rth4  t3      t4              {1.51+limit(dZth,0,1)*0p}
Rth5  t4      Tcase           {1.51+limit(dZth,0,1)*0p}
Cth1  Tj      0               634n
Cth2  t1      0               782n
Cth3  t2      0               70u
Cth4  t3      0               1p
Cth5  t4      0               1p
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT SPB08P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=4.64m     Rg=10        Rd=50u       Rm=1m
.PARAM Inn=6.2      Unn=10       Rmax=0.3     gmin=1.5
.PARAM RRf=498m     Rrbond=2     Rtb=69.4     g2=949m
.PARAM act=2.32
.PARAM Ls=5n        Ld=1n        Lg=8n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               731.6u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {13.45m+limit(dZth,0,1)*4.97m}
Rth2  t1      t2              {144.36m+limit(dZth,0,1)*53.42m}
Rth3  t2      t3              {553.29m+limit(dZth,0,1)*183.54m}
Rth4  t3      t4              {763.11m+limit(dZth,0,1)*764.97m}
Rth5  t4      Tcase           {558.76m+limit(dZth,0,1)*560.13m}
Cth1  Tj      0               28.262u
Cth2  t1      0               83.455u
Cth3  t2      0               610.781u
Cth4  t3      0               394.365u
Cth5  t4      0               38.818m
Cth6  Tcase   0               190m

.ENDS

**********

.SUBCKT SPP08P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=4.64m     Rg=10        Rd=350u      Rm=1m
.PARAM Inn=6.2      Unn=10       Rmax=0.3     gmin=1.5
.PARAM RRf=498m     Rrbond=2     Rtb=69.4     g2=949m
.PARAM act=2.32
.PARAM Ls=5n        Ld=3n        Lg=8n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               731.6u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {13.45m+limit(dZth,0,1)*4.97m}
Rth2  t1      t2              {144.36m+limit(dZth,0,1)*53.42m}
Rth3  t2      t3              {553.29m+limit(dZth,0,1)*183.54m}
Rth4  t3      t4              {763.11m+limit(dZth,0,1)*764.97m}
Rth5  t4      Tcase           {558.76m+limit(dZth,0,1)*560.13m}
Cth1  Tj      0               28.262u
Cth2  t1      0               83.455u
Cth3  t2      0               610.781u
Cth4  t3      0               394.365u
Cth5  t4      0               38.818m
Cth6  Tcase   0               210m

.ENDS

**********

.SUBCKT SPD08P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=2.34m     Rg=10        Rd=50u       Rm=1m
.PARAM Inn=6.2      Unn=10       Rmax=0.3     gmin=1.5
.PARAM RRf=488m     Rrbond=221m  Rtb=23.1     g2=868m
.PARAM act=2.32
.PARAM Ls=2.5n      Ld=1n        Lg=6n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               975.46u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {13.45m+limit(dZth,0,1)*4.97m}
Rth2  t1      t2              {144.36m+limit(dZth,0,1)*53.42m}
Rth3  t2      t3              {553.29m+limit(dZth,0,1)*183.54m}
Rth4  t3      t4              {616.1m+limit(dZth,0,1)*872.22m}
Rth5  t4      Tcase           {479.63m+limit(dZth,0,1)*679.02m}
Cth1  Tj      0               28.262u
Cth2  t1      0               83.455u
Cth3  t2      0               610.781u
Cth4  t3      0               408.828u
Cth5  t4      0               26.817m
Cth6  Tcase   0               70m

.ENDS

**********

.SUBCKT SPU08P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=2.34m     Rg=10        Rd=350u      Rm=1m
.PARAM Inn=6.2      Unn=10       Rmax=0.3     gmin=1.5
.PARAM RRf=488m     Rrbond=221m  Rtb=23.1     g2=868m
.PARAM act=2.32
.PARAM Ls=2.5n      Ld=3n        Lg=6n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               975.46u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {13.45m+limit(dZth,0,1)*4.97m}
Rth2  t1      t2              {144.36m+limit(dZth,0,1)*53.42m}
Rth3  t2      t3              {553.29m+limit(dZth,0,1)*183.54m}
Rth4  t3      t4              {616.1m+limit(dZth,0,1)*872.22m}
Rth5  t4      Tcase           {479.63m+limit(dZth,0,1)*679.02m}
Cth1  Tj      0               28.262u
Cth2  t1      0               83.455u
Cth3  t2      0               610.781u
Cth4  t3      0               408.828u
Cth5  t4      0               26.817m
Cth6  Tcase   0               70m

.ENDS

**********

.SUBCKT BSP170P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=22.1m     Rg=10        Rd=2m        Rm=2m
.PARAM Inn=1.9      Unn=10       Rmax=0.3     gmin=1.4
.PARAM RRf=500m     Rrbond=35    Rtb=278.2    g2=1000m
.PARAM act=2.32
.PARAM Ls=3n        Ld=2n        Lg=3n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               9.01u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {13.37m+limit(dZth,0,1)*4.95m}
Rth2  t1      t2              {143.84m+limit(dZth,0,1)*53.23m}
Rth3  t2      t3              {1.2+limit(dZth,0,1)*186.76m}
Rth4  t3      t4              {3.28+limit(dZth,0,1)*2.34}
Rth5  t4      Tcase           {7.46+limit(dZth,0,1)*5.32}
Cth1  Tj      0               23.6u
Cth2  t1      0               21.7u
Cth3  t2      0               496u
Cth4  t3      0               805u
Cth5  t4      0               13.8m
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT BSO612CV_p drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=13.18m    Rg=10        Rd=1m        Rm=2m
.PARAM Inn=2        Unn=10       Rmax=0.3     gmin=1.2
.PARAM RRf=500m     Rrbond=10    Rtb=150.6    g2=999m
.PARAM act=2.32
.PARAM Ls=3n        Ld=3n        Lg=3n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               14.63u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {13.37m+limit(dZth,0,1)*4.95m}
Rth2  t1      t2              {143.84m+limit(dZth,0,1)*53.23m}
Rth3  t2      t3              {3.93+limit(dZth,0,1)*186.76m}
Rth4  t3      t4              {20+limit(dZth,0,1)*0p}
Rth5  t4      Tcase           {22+limit(dZth,0,1)*0p}
Cth1  Tj      0               23.6u
Cth2  t1      0               21.7u
Cth3  t2      0               683u
Cth4  t3      0               5.81m
Cth5  t4      0               39.5m
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT SPB18P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=1.81m     Rg=5         Rd=50u       Rm=730u
.PARAM Inn=13.2     Unn=10       Rmax=130m    gmin=4
.PARAM RRf=473m     Rrbond=124m  Rtb=17.4     g2=822m
.PARAM act=5.04
.PARAM Ls=5n        Ld=1n        Lg=8n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               2.93m
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {6.19m+limit(dZth,0,1)*2.29m}
Rth2  t1      t2              {68.7m+limit(dZth,0,1)*25.43m}
Rth3  t2      t3              {255.49m+limit(dZth,0,1)*83.66m}
Rth4  t3      t4              {351.28m+limit(dZth,0,1)*323.25m}
Rth5  t4      Tcase           {382.1m+limit(dZth,0,1)*351.61m}
Cth1  Tj      0               61.397u
Cth2  t1      0               175.351u
Cth3  t2      0               1.319m
Cth4  t3      0               856.724u
Cth5  t4      0               50.362m
Cth6  Tcase   0               190m

.ENDS

**********

.SUBCKT SPP18P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=1.81m     Rg=5         Rd=350u      Rm=730u
.PARAM Inn=13.2     Unn=10       Rmax=130m    gmin=4
.PARAM RRf=473m     Rrbond=124m  Rtb=17.4     g2=822m
.PARAM act=5.04
.PARAM Ls=5n        Ld=3n        Lg=8n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               2.93m
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {6.19m+limit(dZth,0,1)*2.29m}
Rth2  t1      t2              {68.7m+limit(dZth,0,1)*25.43m}
Rth3  t2      t3              {255.49m+limit(dZth,0,1)*83.66m}
Rth4  t3      t4              {351.28m+limit(dZth,0,1)*323.25m}
Rth5  t4      Tcase           {382.1m+limit(dZth,0,1)*351.61m}
Cth1  Tj      0               61.397u
Cth2  t1      0               175.351u
Cth3  t2      0               1.319m
Cth4  t3      0               856.724u
Cth5  t4      0               50.362m
Cth6  Tcase   0               210m

.ENDS

**********

.SUBCKT SPD18P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=2.61m     Rg=5         Rd=50u       Rm=1m
.PARAM Inn=13.2     Unn=10       Rmax=130m    gmin=4
.PARAM RRf=488m     Rrbond=230m  Rtb=23.6     g2=871m
.PARAM act=5.04
.PARAM Ls=3.5n      Ld=1n        Lg=6n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               955.96u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {6.19m+limit(dZth,0,1)*2.29m}
Rth2  t1      t2              {68.7m+limit(dZth,0,1)*25.43m}
Rth3  t2      t3              {255.49m+limit(dZth,0,1)*83.66m}
Rth4  t3      t4              {283.6m+limit(dZth,0,1)*336.05m}
Rth5  t4      Tcase           {360.92m+limit(dZth,0,1)*427.67m}
Cth1  Tj      0               61.397u
Cth2  t1      0               175.351u
Cth3  t2      0               1.319m
Cth4  t3      0               888.144u
Cth5  t4      0               27.171m
Cth6  Tcase   0               70m

.ENDS

**********

.SUBCKT SPU18P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=2.61m     Rg=5         Rd=350u      Rm=1m
.PARAM Inn=13.2     Unn=10       Rmax=130m    gmin=4
.PARAM RRf=488m     Rrbond=230m  Rtb=23.6     g2=871m
.PARAM act=5.04
.PARAM Ls=3.5n      Ld=3n        Lg=6n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               955.96u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {6.19m+limit(dZth,0,1)*2.29m}
Rth2  t1      t2              {68.7m+limit(dZth,0,1)*25.43m}
Rth3  t2      t3              {255.49m+limit(dZth,0,1)*83.66m}
Rth4  t3      t4              {283.6m+limit(dZth,0,1)*336.05m}
Rth5  t4      Tcase           {360.92m+limit(dZth,0,1)*427.67m}
Cth1  Tj      0               61.397u
Cth2  t1      0               175.351u
Cth3  t2      0               1.319m
Cth4  t3      0               888.144u
Cth5  t4      0               27.171m
Cth6  Tcase   0               70m

.ENDS

**********

.SUBCKT BSP613P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=11.01m    Rg=5         Rd=2m        Rm=2m
.PARAM Inn=2.9      Unn=10       Rmax=130m    gmin=2.3
.PARAM RRf=500m     Rrbond=7     Rtb=120.5    g2=999m
.PARAM act=5.04
.PARAM Ls=3n        Ld=3n        Lg=3n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               26.34u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {6.18m+limit(dZth,0,1)*2.29m}
Rth2  t1      t2              {68.7m+limit(dZth,0,1)*25.43m}
Rth3  t2      t3              {1.46+limit(dZth,0,1)*80.55m}
Rth4  t3      t4              {5.21+limit(dZth,0,1)*5.84}
Rth5  t4      Tcase           {2.97+limit(dZth,0,1)*3.33}
Cth1  Tj      0               61u
Cth2  t1      0               175u
Cth3  t2      0               1.8m
Cth4  t3      0               7.7m
Cth5  t4      0               112m
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT BSO613SPV drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=9.39m     Rg=5         Rd=1m        Rm=2m
.PARAM Inn=3.44     Unn=10       Rmax=130m    gmin=2.2
.PARAM RRf=500m     Rrbond=5     Rtb=100.4    g2=999m
.PARAM act=5.04
.PARAM Ls=3n        Ld=3n        Lg=3n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               21.95u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {6.18m+limit(dZth,0,1)*2.29m}
Rth2  t1      t2              {68.7m+limit(dZth,0,1)*25.43m}
Rth3  t2      t3              {1.54+limit(dZth,0,1)*80.55m}
Rth4  t3      t4              {8.05+limit(dZth,0,1)*517.84m}
Rth5  t4      Tcase           {13.82+limit(dZth,0,1)*889.01m}
Cth1  Tj      0               61u
Cth2  t1      0               175u
Cth3  t2      0               1.3m
Cth4  t3      0               7.91m
Cth5  t4      0               67m
Cth6  Tcase   0               1p

.ENDS

**********

.SUBCKT SPB80P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=1.03m     Rg=3         Rd=50u       Rm=380u
.PARAM Inn=64       Unn=10       Rmax=23m     gmin=18
.PARAM RRf=393m     Rrbond=31m   Rtb=8.7      g2=698m
.PARAM act=27.45
.PARAM Ls=3.5n      Ld=1n        Lg=8n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               5.85m
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {1.14m+limit(dZth,0,1)*417u}
Rth2  t1      t2              {13.14m+limit(dZth,0,1)*4.87m}
Rth3  t2      t3              {51.54m+limit(dZth,0,1)*15.17m}
Rth4  t3      t4              {64.5m+limit(dZth,0,1)*20.93m}
Rth5  t4      Tcase           {172.36m+limit(dZth,0,1)*55.93m}
Cth1  Tj      0               334.394u
Cth2  t1      0               916.689u
Cth3  t2      0               6.391m
Cth4  t3      0               4.666m
Cth5  t4      0               137.823m
Cth6  Tcase   0               190m

.ENDS

**********

.SUBCKT SPP80P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=1.03m     Rg=3         Rd=350u      Rm=380u
.PARAM Inn=64       Unn=10       Rmax=23m     gmin=18
.PARAM RRf=393m     Rrbond=31m   Rtb=8.7      g2=698m
.PARAM act=27.45
.PARAM Ls=3.5n      Ld=3n        Lg=8n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               5.85m
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {1.14m+limit(dZth,0,1)*417u}
Rth2  t1      t2              {13.14m+limit(dZth,0,1)*4.87m}
Rth3  t2      t3              {51.54m+limit(dZth,0,1)*15.17m}
Rth4  t3      t4              {64.5m+limit(dZth,0,1)*20.93m}
Rth5  t4      Tcase           {172.36m+limit(dZth,0,1)*55.93m}
Cth1  Tj      0               334.394u
Cth2  t1      0               916.689u
Cth3  t2      0               6.391m
Cth4  t3      0               4.666m
Cth5  t4      0               137.823m
Cth6  Tcase   0               210m

.ENDS

**********

.SUBCKT SPD30P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=2.96m     Rg=3         Rd=50u       Rm=2m
.PARAM Inn=21.5     Unn=10       Rmax=75m     gmin=5.2
.PARAM RRf=488m     Rrbond=230m  Rtb=23.6     g2=871m
.PARAM act=8.38
.PARAM Ls=3.5n      Ld=1n        Lg=6n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               955.96u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {3.72m+limit(dZth,0,1)*1.38m}
Rth2  t1      t2              {41.99m+limit(dZth,0,1)*15.54m}
Rth3  t2      t3              {159.81m+limit(dZth,0,1)*50.07m}
Rth4  t3      t4              {170.57m+limit(dZth,0,1)*180.17m}
Rth5  t4      Tcase           {280.48m+limit(dZth,0,1)*296.27m}
Cth1  Tj      0               102.085u
Cth2  t1      0               286.928u
Cth3  t2      0               2.088m
Cth4  t3      0               1.477m
Cth5  t4      0               35.062m
Cth6  Tcase   0               70m

.ENDS

**********

.SUBCKT SPU30P06P drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 dZth=0

.PARAM Rs=2.96m     Rg=3         Rd=350u      Rm=2m
.PARAM Inn=21.5     Unn=10       Rmax=75m     gmin=5.2
.PARAM RRf=488m     Rrbond=230m  Rtb=23.6     g2=871m
.PARAM act=8.38
.PARAM Ls=3.5n      Ld=3n        Lg=6n
.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=1
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
Rsb   source s1    10
Rga   gate   g1    10
Rdb   drain  d2    10

G_TH  0    Tb  VALUE =  {Pb(abs(I(Ls)),V(Tj,Tcase),Rrbond*(1+(limit((V(Tb)+V(Tj))/2,-200,999)-25)*4m))}
Cthb  Tb      0               955.96u
Rthb  Tb      Tj              {Rtb}
Rth1  Tj      t1              {3.72m+limit(dZth,0,1)*1.38m}
Rth2  t1      t2              {41.99m+limit(dZth,0,1)*15.54m}
Rth3  t2      t3              {159.81m+limit(dZth,0,1)*50.07m}
Rth4  t3      t4              {170.57m+limit(dZth,0,1)*180.17m}
Rth5  t4      Tcase           {280.48m+limit(dZth,0,1)*296.27m}
Cth1  Tj      0               102.085u
Cth2  t1      0               286.928u
Cth3  t2      0               2.088m
Cth4  t3      0               1.477m
Cth5  t4      0               35.062m
Cth6  Tcase   0               70m

.ENDS

**********

**********

.SUBCKT BSS83P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=76.19m    Rg=10        Rd=30m       Rm=2m
.PARAM Inn=0.33     Unn=10       Rmax=2       gmin=264.82m
.PARAM act=0.32
.PARAM Ls=2n        Ld=1n        Lg=2n
X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSS84P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=75.39m    Rg=10        Rd=30m       Rm=1m
.PARAM Inn=0.17     Unn=10       Rmax=8       gmin=71.59m
.PARAM act=0.0915
.PARAM Ls=2n        Ld=1n        Lg=2n
X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSS84PW_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=75.33m    Rg=10        Rd=50m       Rm=1m
.PARAM Inn=0.15     Unn=10       Rmax=8       gmin=80m
.PARAM act=0.0915
.PARAM Ls=2n        Ld=1n        Lg=2n
X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSP171P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=24.57m    Rg=10        Rd=2m        Rm=2m
.PARAM Inn=1.5      Unn=10       Rmax=0.3     gmin=1
.PARAM act=2.32
.PARAM Ls=3n        Ld=2n        Lg=2n
X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSO615C_p_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=9.62m     Rg=10        Rd=1m        Rm=2m
.PARAM Inn=2        Unn=10       Rmax=0.3     gmin=1.3
.PARAM act=2.32
.PARAM Ls=3n        Ld=3n        Lg=3n
X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPD09P06PL_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=3.48m     Rg=10        Rd=50u       Rm=1m
.PARAM Inn=6.9      Unn=10       Rmax=0.25    gmin=2.03
.PARAM act=2.32
.PARAM Ls=3.5n      Ld=1n        Lg=6n
X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPU09P06PL_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=3.48m     Rg=10        Rd=350u      Rm=1m
.PARAM Inn=6.9      Unn=10       Rmax=0.25    gmin=2.03
.PARAM act=2.32
.PARAM Ls=3.5n      Ld=3n        Lg=6n
X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSP315P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=32.41m    Rg=10        Rd=2m        Rm=1m
.PARAM Inn=1.17     Unn=10       Rmax=0.8     gmin=799.93m
.PARAM act=0.8
.PARAM Ls=2n        Ld=1n        Lg=3n
X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSR315P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=63.27m    Rg=10        Rd=2m        Rm=1m
.PARAM Inn=0.62     Unn=10       Rmax=0.8     gmin=588.56m
.PARAM act=0.8
.PARAM Ls=2n        Ld=1n        Lg=3n
X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SISC0_25P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=1.21m     Rg=10        Rd=1p        Rm=1m
.PARAM Inn=0.17     Unn=10       Rmax=8       gmin=71.63m
.PARAM act=0.0915
.PARAM Ls=1p        Ld=1p        Lg=1p
X1  d1 g s Tj P_60_l_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPB08P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=4.64m     Rg=10        Rd=50u       Rm=1m
.PARAM Inn=6.2      Unn=10       Rmax=0.3     gmin=1.5
.PARAM act=2.32
.PARAM Ls=5n        Ld=1n        Lg=8n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPP08P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=4.64m     Rg=10        Rd=350u      Rm=1m
.PARAM Inn=6.2      Unn=10       Rmax=0.3     gmin=1.5
.PARAM act=2.32
.PARAM Ls=5n        Ld=3n        Lg=8n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPD08P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=2.34m     Rg=10        Rd=50u       Rm=1m
.PARAM Inn=6.2      Unn=10       Rmax=0.3     gmin=1.5
.PARAM act=2.32
.PARAM Ls=2.5n      Ld=1n        Lg=6n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPU08P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=2.34m     Rg=10        Rd=350u      Rm=1m
.PARAM Inn=6.2      Unn=10       Rmax=0.3     gmin=1.5
.PARAM act=2.32
.PARAM Ls=2.5n      Ld=3n        Lg=6n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSP170P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=22.1m     Rg=10        Rd=2m        Rm=2m
.PARAM Inn=1.9      Unn=10       Rmax=0.3     gmin=1.4
.PARAM act=2.32
.PARAM Ls=3n        Ld=2n        Lg=3n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSO612CV_p_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=13.18m    Rg=10        Rd=1m        Rm=2m
.PARAM Inn=2        Unn=10       Rmax=0.3     gmin=1.2
.PARAM act=2.32
.PARAM Ls=3n        Ld=3n        Lg=3n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPB18P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=1.81m     Rg=5         Rd=50u       Rm=730u
.PARAM Inn=13.2     Unn=10       Rmax=130m    gmin=4
.PARAM act=5.04
.PARAM Ls=5n        Ld=1n        Lg=8n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPP18P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=1.81m     Rg=5         Rd=350u      Rm=730u
.PARAM Inn=13.2     Unn=10       Rmax=130m    gmin=4
.PARAM act=5.04
.PARAM Ls=5n        Ld=3n        Lg=8n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPD18P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=2.61m     Rg=5         Rd=50u       Rm=1m
.PARAM Inn=13.2     Unn=10       Rmax=130m    gmin=4
.PARAM act=5.04
.PARAM Ls=3.5n      Ld=1n        Lg=6n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPU18P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=2.61m     Rg=5         Rd=350u      Rm=1m
.PARAM Inn=13.2     Unn=10       Rmax=130m    gmin=4
.PARAM act=5.04
.PARAM Ls=3.5n      Ld=3n        Lg=6n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSP613P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=11.01m    Rg=5         Rd=2m        Rm=2m
.PARAM Inn=2.9      Unn=10       Rmax=130m    gmin=2.3
.PARAM act=5.04
.PARAM Ls=3n        Ld=3n        Lg=3n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSO613SPV_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=9.39m     Rg=5         Rd=1m        Rm=2m
.PARAM Inn=3.44     Unn=10       Rmax=130m    gmin=2.2
.PARAM act=5.04
.PARAM Ls=3n        Ld=3n        Lg=3n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPB80P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=1.03m     Rg=3         Rd=50u       Rm=380u
.PARAM Inn=64       Unn=10       Rmax=23m     gmin=18
.PARAM act=27.45
.PARAM Ls=3.5n      Ld=1n        Lg=8n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPP80P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=1.03m     Rg=3         Rd=350u      Rm=380u
.PARAM Inn=64       Unn=10       Rmax=23m     gmin=18
.PARAM act=27.45
.PARAM Ls=3.5n      Ld=3n        Lg=8n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPD30P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=2.96m     Rg=3         Rd=50u       Rm=2m
.PARAM Inn=21.5     Unn=10       Rmax=75m     gmin=5.2
.PARAM act=8.38
.PARAM Ls=3.5n      Ld=1n        Lg=6n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT SPU30P06P_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0

.PARAM Rs=2.96m     Rg=3         Rd=350u      Rm=2m
.PARAM Inn=21.5     Unn=10       Rmax=75m     gmin=5.2
.PARAM act=8.38
.PARAM Ls=3.5n      Ld=3n        Lg=6n
X1  d1 g s Tj P_60_n_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} dC={dC} heat=0
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m))}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT  BSS83P_L0  drain  gate  source

*package
Lg     gate  g1   2n
Ld     drain d1   1n
Ls     source s1  2n
Rs      s1    s2  76.19m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=521.6m VTO=-2.25 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    1.05  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=44.48p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=1.38n  N=1.5    RS=18.75m   EG=1.12    TT=30n)
Rdiode  d1  21    115.62m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   90p
.MODEL     DGD    D(M=0.7   CJO=90p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   44.8p

.ENDS BSS83P_L0

**********

.SUBCKT  BSS84P_L0  drain  gate  source

*package
Lg     gate  g1   2n
Ld     drain d1   1n
Ls     source s1  2n
Rs      s1    s2  75.39m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=149.15m VTO=-2.25 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    3.67  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=12.72p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=393.45p  N=1.5    RS=65.57m   EG=1.12    TT=30n)
Rdiode  d1  21    404.37m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   32.88p
.MODEL     DGD    D(M=0.7   CJO=32.88p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   12.81p

.ENDS BSS84P_L0

**********

.SUBCKT  BSS84PW_L0  drain  gate  source

*package
Lg     gate  g1   2n
Ld     drain d1   1n
Ls     source s1  2n
Rs      s1    s2  75.33m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=149.15m VTO=-2.25 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    3.67  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=12.72p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=393.45p  N=1.5    RS=65.57m   EG=1.12    TT=30n)
Rdiode  d1  21    404.37m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   32.88p
.MODEL     DGD    D(M=0.7   CJO=32.88p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   12.81p

.ENDS BSS84PW_L0

**********

.SUBCKT  BSP171P_L0  drain  gate  source

*package
Lg     gate  g1   2n
Ld     drain d1   2n
Ls     source s1  3n
Rs      s1    s2  24.57m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=3.78 VTO=-2.25 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    144.83m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=322.48p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=9.98n  N=1.5    RS=2.59m   EG=1.12    TT=30n)
Rdiode  d1  21    15.95m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   590p
.MODEL     DGD    D(M=0.7   CJO=590p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   324.8p

.ENDS BSP171P_L0

**********

.SUBCKT  BSO615C_p_L0  drain  gate  source

*package
Lg     gate  g1   3n
Ld     drain d1   3n
Ls     source s1  3n
Rs      s1    s2  9.62m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=3.78 VTO=-2.25 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    144.83m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=322.48p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=9.98n  N=1.5    RS=2.59m   EG=1.12    TT=30n)
Rdiode  d1  21    15.95m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   590p
.MODEL     DGD    D(M=0.7   CJO=590p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   324.8p

.ENDS BSO615C_p_L0

**********

.SUBCKT  SPD09P06PL_L0  drain  gate  source

*package
Lg     gate  g1   6n
Ld     drain d1   1n
Ls     source s1  3.5n
Rs      s1    s2  3.48m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=3.78 VTO=-2.25 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    144.83m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=322.48p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=9.98n  N=1.5    RS=2.59m   EG=1.12    TT=30n)
Rdiode  d1  21    15.95m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   590p
.MODEL     DGD    D(M=0.7   CJO=590p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   324.8p

.ENDS SPD09P06PL_L0

**********

.SUBCKT  SPU09P06PL_L0  drain  gate  source

*package
Lg     gate  g1   6n
Ld     drain d1   3n
Ls     source s1  3.5n
Rs      s1    s2  3.48m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=3.78 VTO=-2.25 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    144.83m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=322.48p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=9.98n  N=1.5    RS=2.59m   EG=1.12    TT=30n)
Rdiode  d1  21    15.95m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   590p
.MODEL     DGD    D(M=0.7   CJO=590p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   324.8p

.ENDS SPU09P06PL_L0

**********

.SUBCKT  BSP315P_L0  drain  gate  source

*package
Lg     gate  g1   3n
Ld     drain d1   1n
Ls     source s1  2n
Rs      s1    s2  32.41m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=1.3 VTO=-2.25 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    420m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=111.2p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=3.44n  N=1.5    RS=7.5m   EG=1.12    TT=30n)
Rdiode  d1  21    46.25m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   210p
.MODEL     DGD    D(M=0.7   CJO=210p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   112p

.ENDS BSP315P_L0

**********

.SUBCKT  BSR315P_L0  drain  gate  source

*package
Lg     gate  g1   3n
Ld     drain d1   1n
Ls     source s1  2n
Rs      s1    s2  63.27m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=1.3 VTO=-2.25 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    420m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=111.2p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=3.44n  N=1.5    RS=7.5m   EG=1.12    TT=30n)
Rdiode  d1  21    46.25m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   210p
.MODEL     DGD    D(M=0.7   CJO=210p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   112p

.ENDS BSR315P_L0

**********

.SUBCKT  SISC0_25P06P_L0  drain  gate  source

*package
Lg     gate  g1   1p
Ld     drain d1   1p
Ls     source s1  1p
Rs      s1    s2  1.21m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=149.15m VTO=-2.25 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    3.67  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=12.72p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=393.45p  N=1.5    RS=65.57m   EG=1.12    TT=30n)
Rdiode  d1  21    404.37m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   32.88p
.MODEL     DGD    D(M=0.7   CJO=32.88p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   12.81p

.ENDS SISC0_25P06P_L0

**********

.SUBCKT  SPB08P06P_L0  drain  gate  source

*package
Lg     gate  g1   8n
Ld     drain d1   1n
Ls     source s1  5n
Rs      s1    s2  4.64m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=2.6 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    144.83m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=322.48p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=9.98n  N=1.5    RS=2.59m   EG=1.12    TT=30n)
Rdiode  d1  21    15.95m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   427.6p
.MODEL     DGD    D(M=0.52   CJO=427.6p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   278.4p

.ENDS SPB08P06P_L0

**********

.SUBCKT  SPP08P06P_L0  drain  gate  source

*package
Lg     gate  g1   8n
Ld     drain d1   3n
Ls     source s1  5n
Rs      s1    s2  4.64m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=2.6 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    144.83m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=322.48p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=9.98n  N=1.5    RS=2.59m   EG=1.12    TT=30n)
Rdiode  d1  21    15.95m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   427.6p
.MODEL     DGD    D(M=0.52   CJO=427.6p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   278.4p

.ENDS SPP08P06P_L0

**********

.SUBCKT  SPD08P06P_L0  drain  gate  source

*package
Lg     gate  g1   6n
Ld     drain d1   1n
Ls     source s1  2.5n
Rs      s1    s2  2.34m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=2.6 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    144.83m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=322.48p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=9.98n  N=1.5    RS=2.59m   EG=1.12    TT=30n)
Rdiode  d1  21    15.95m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   427.6p
.MODEL     DGD    D(M=0.52   CJO=427.6p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   278.4p

.ENDS SPD08P06P_L0

**********

.SUBCKT  SPU08P06P_L0  drain  gate  source

*package
Lg     gate  g1   6n
Ld     drain d1   3n
Ls     source s1  2.5n
Rs      s1    s2  2.34m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=2.6 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    144.83m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=322.48p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=9.98n  N=1.5    RS=2.59m   EG=1.12    TT=30n)
Rdiode  d1  21    15.95m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   427.6p
.MODEL     DGD    D(M=0.52   CJO=427.6p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   278.4p

.ENDS SPU08P06P_L0

**********

.SUBCKT  BSP170P_L0  drain  gate  source

*package
Lg     gate  g1   3n
Ld     drain d1   2n
Ls     source s1  3n
Rs      s1    s2  22.1m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=2.6 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    144.83m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=322.48p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=9.98n  N=1.5    RS=2.59m   EG=1.12    TT=30n)
Rdiode  d1  21    15.95m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   427.6p
.MODEL     DGD    D(M=0.52   CJO=427.6p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   278.4p

.ENDS BSP170P_L0

**********

.SUBCKT  BSO612CV_p_L0  drain  gate  source

*package
Lg     gate  g1   3n
Ld     drain d1   3n
Ls     source s1  3n
Rs      s1    s2  13.18m

Rg     g1    g2    10

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=2.6 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    144.83m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=322.48p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=9.98n  N=1.5    RS=2.59m   EG=1.12    TT=30n)
Rdiode  d1  21    15.95m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   427.6p
.MODEL     DGD    D(M=0.52   CJO=427.6p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   278.4p

.ENDS BSO612CV_p_L0

**********

.SUBCKT  SPB18P06P_L0  drain  gate  source

*package
Lg     gate  g1   8n
Ld     drain d1   1n
Ls     source s1  5n
Rs      s1    s2  1.81m

Rg     g1    g2    5

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=5.64 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    66.67m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=700.56p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=21.67n  N=1.5    RS=1.19m   EG=1.12    TT=30n)
Rdiode  d1  21    7.34m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   917.2p
.MODEL     DGD    D(M=0.52   CJO=917.2p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   604.8p

.ENDS SPB18P06P_L0

**********

.SUBCKT  SPP18P06P_L0  drain  gate  source

*package
Lg     gate  g1   8n
Ld     drain d1   3n
Ls     source s1  5n
Rs      s1    s2  1.81m

Rg     g1    g2    5

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=5.64 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    66.67m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=700.56p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=21.67n  N=1.5    RS=1.19m   EG=1.12    TT=30n)
Rdiode  d1  21    7.34m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   917.2p
.MODEL     DGD    D(M=0.52   CJO=917.2p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   604.8p

.ENDS SPP18P06P_L0

**********

.SUBCKT  SPD18P06P_L0  drain  gate  source

*package
Lg     gate  g1   6n
Ld     drain d1   1n
Ls     source s1  3.5n
Rs      s1    s2  2.61m

Rg     g1    g2    5

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=5.64 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    66.67m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=700.56p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=21.67n  N=1.5    RS=1.19m   EG=1.12    TT=30n)
Rdiode  d1  21    7.34m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   917.2p
.MODEL     DGD    D(M=0.52   CJO=917.2p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   604.8p

.ENDS SPD18P06P_L0

**********

.SUBCKT  SPU18P06P_L0  drain  gate  source

*package
Lg     gate  g1   6n
Ld     drain d1   3n
Ls     source s1  3.5n
Rs      s1    s2  2.61m

Rg     g1    g2    5

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=5.64 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    66.67m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=700.56p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=21.67n  N=1.5    RS=1.19m   EG=1.12    TT=30n)
Rdiode  d1  21    7.34m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   917.2p
.MODEL     DGD    D(M=0.52   CJO=917.2p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   604.8p

.ENDS SPU18P06P_L0

**********

.SUBCKT  BSP613P_L0  drain  gate  source

*package
Lg     gate  g1   3n
Ld     drain d1   3n
Ls     source s1  3n
Rs      s1    s2  11.01m

Rg     g1    g2    5

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=5.64 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    66.67m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=700.56p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=21.67n  N=1.5    RS=1.19m   EG=1.12    TT=30n)
Rdiode  d1  21    7.34m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   917.2p
.MODEL     DGD    D(M=0.52   CJO=917.2p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   604.8p

.ENDS BSP613P_L0

**********

.SUBCKT  BSO613SPV_L0  drain  gate  source

*package
Lg     gate  g1   3n
Ld     drain d1   3n
Ls     source s1  3n
Rs      s1    s2  9.39m

Rg     g1    g2    5

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=5.64 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    66.67m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=700.56p     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=21.67n  N=1.5    RS=1.19m   EG=1.12    TT=30n)
Rdiode  d1  21    7.34m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   917.2p
.MODEL     DGD    D(M=0.52   CJO=917.2p   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   604.8p

.ENDS BSO613SPV_L0

**********

.SUBCKT  SPB80P06P_L0  drain  gate  source

*package
Lg     gate  g1   8n
Ld     drain d1   1n
Ls     source s1  3.5n
Rs      s1    s2  1.03m

Rg     g1    g2    3

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=30.74 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    12.24m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=3.82n     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=118.03n  N=1.5    RS=218.58u   EG=1.12    TT=30n)
Rdiode  d1  21    1.35m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   4.95n
.MODEL     DGD    D(M=0.52   CJO=4.95n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   3.29n

.ENDS SPB80P06P_L0

**********

.SUBCKT  SPP80P06P_L0  drain  gate  source

*package
Lg     gate  g1   8n
Ld     drain d1   3n
Ls     source s1  3.5n
Rs      s1    s2  1.03m

Rg     g1    g2    3

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=30.74 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    12.24m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=3.82n     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=118.03n  N=1.5    RS=218.58u   EG=1.12    TT=30n)
Rdiode  d1  21    1.35m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   4.95n
.MODEL     DGD    D(M=0.52   CJO=4.95n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   3.29n

.ENDS SPP80P06P_L0

**********

.SUBCKT  SPD30P06P_L0  drain  gate  source

*package
Lg     gate  g1   6n
Ld     drain d1   1n
Ls     source s1  3.5n
Rs      s1    s2  2.96m

Rg     g1    g2    3

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=9.39 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    40.1m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=1.16n     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=36.03n  N=1.5    RS=715.99u   EG=1.12    TT=30n)
Rdiode  d1  21    4.42m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   1.52n
.MODEL     DGD    D(M=0.52   CJO=1.52n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   1.01n

.ENDS SPD30P06P_L0

**********

.SUBCKT  SPU30P06P_L0  drain  gate  source

*package
Lg     gate  g1   6n
Ld     drain d1   3n
Ls     source s1  3.5n
Rs      s1    s2  2.96m

Rg     g1    g2    3

*MOSFET
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS PMOS ( KP=9.39 VTO=-3.15 THETA=0.02 ETA=0.00   LEVEL=3)
Rd     d1    d2    40.1m  TC=5.5m

*diode
Dbd     d2    s2    Dbt
.MODEL     Dbt    D(BV=70   M=0.5      CJO=1.16n     VJ=1)
Dbody   21   s2    DBODY
.MODEL DBODY  D(IS=36.03n  N=1.5    RS=715.99u   EG=1.12    TT=30n)
Rdiode  d1  21    4.42m  TC=2m

.MODEL   sw    PMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   1.52n
.MODEL     DGD    D(M=0.52   CJO=1.52n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       d2   a   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2   1.01n

.ENDS SPU30P06P_L0

**********

*^^^^^^^^  End of included SPICE model from PFET_60V.lib ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from BAV70LT1G.cir vvvvvvvv
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************

.SUBCKT BAV70LT1G 1 2
*
* The resistor R1 does not reflect
* a physical device.  Instead it
* improves modeling in the reverse
* mode of operation.
*
R1 1 2 2.3E+9
D1 1 2 bav70lt1g

* Model generated on 10/18/07
* MODEL FORMAT: SPICE3
.MODEL bav70lt1g d
+IS=7.85162e-09 RS=1.24107 N=1.93575 EG=1.1965
+XTI=0.5 BV=1000 IBV=0.0001 CJO=9.14173e-13
+VJ=2.14855 M=0.2 FC=0.5 TT=1e-09
+KF=0 AF=1
.ENDS
*^^^^^^^^  End of included SPICE model from BAV70LT1G.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from PDTC114EU.cir vvvvvvvv
*
**********************************************************
*
* PDTC114EU
*
* NXP Semiconductors
*
* Resistor equipped NPN transistor (RET)
* IC   = 100 mA
* VCEO = 50 V
* hFE  = min. 30 @ 5V/5mA
* R1   = 10 Kohm
* R2   = 10 Kohm
*
*
* Package pinning does not match Spice model pinning.
* Package: SOT 323
*
* Package Pin 1: Base
* Package Pin 2: Emitter
* Package Pin 3: Collector
*
*
* Extraction date (week/year): 43/2014
* Simulator: Spice 3
*
**********************************************************
*sb#
* Please note: ---Resistances R1 and R2 are not part of the
* model and have to be added separately.---
* Diode D is dedicated to improve modeling in  reverse
* area of operation and does not reflect a physical device.
*
.SUBCKT PDTC114EU 1 2 3
*
Q1 1 4 3 MAIN
D1 2 1 DIODE
R1 2 4 10K
R2 4 3 10K
.MODEL MAIN NPN
+ IS = 7.342E-015
+ NF = 0.9765
+ ISE = 4.422E-015
+ NE = 1.742
+ BF = 296
+ IKF = 0.1257
+ VAF = 45.06
+ NR = 0.974
+ ISC = 8.521E-016
+ NC = 1.094
+ BR = 17.5
+ IKR = 1
+ VAR = 39
+ RB = 160
+ IRB = 0.000145
+ RBM = 4.2
+ RE = 0.3998
+ RC = 0.5587
+ XTB = 0
+ EG = 1.11
+ XTI = 3
+ CJE = 1.014E-011
+ VJE = 0.67
+ MJE = 0.3454
+ TF = 5.92E-010
+ XTF = 25
+ VTF = 2
+ ITF = 0.18
+ PTF = 0
+ CJC = 2.96E-012
+ VJC = 0.4591
+ MJC = 0.2956
+ XCJC = 1
+ TR = 8.7E-008
+ CJS = 0
+ VJS = 0.75
+ MJS = 0.333
+ FC = 0.78
.MODEL DIODE D
+ IS = 1.077E-015
+ N = 0.988
+ BV = 1000
+ IBV = 0.001
+ RS = 857.2
+ CJO = 0
+ VJ = 1
+ M = 0.5
+ FC = 0
+ TT = 0
+ EG = 1.11
+ XTI = 3
.ENDS
*^^^^^^^^  End of included SPICE model from PDTC114EU.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from OptiMOS2_20V.lib vvvvvvvv

*****************************************************************
* INFINEON Power Transistors                                    *
* Level-1 / 3 SPICE Library for OptiMOS/OptiMOS2 n-Channel      *
* Transistors (20V)                                             *
* Version 240715                                                *
*                                                               *
*****************************************************************
*                                                               *
* The Simulation Model is subject to change without notice. In  *
* addition, models can be a useful tool in evaluating device    *
* performance, they cannot reflect the accurate device          *
* performance under all conditions, nor are they intended to    *
* replace bread boarding for final verification. Infineon       *
* therefore does not assume any warranty or liability           *
* whatsoever arising from their use. Infineon does not assume   *
* any warranty or liability for the values and functions of the *
* Simulation Model.                                             *
* The methods and results of the Simulation Model are to the    *
* best of our knowledge                                         *
* correct. However, the user is fully responsible to verify and *
* validate these results under the operating conditions and in  *
* the environment of its application. Infineon will not bear    *
* the responsibility arising out of or in connection with any   *
* malfunction of the Simulation Models.                         *
* Models provided by Infineon are not warranted by Infineon as  *
* completely and comprehensively representing all the           *
* specifications and operating characteristics of the           *
* semiconductor products to which these models relate. The      *
* models describe the characteristics of typical devices. In    *
* all cases, the current data sheet information for a given     *
* device is the conclusive design guideline and the only actual *
* performance specification.                                    *
*                                                               *
*                                                               *
* This library contains models of the following INFINEON        *
* OptiMOS/OptiMOS2 transistors:                                 *
*                                                               *
*  OptiMOS2 20V ULL, 1.8 V rated                                *
* BSR802N                                                       *
* BSL802SN                                                      *
* BSL806N  (L3 modeled as single only)                          *
* BSS806N                                                       *
* BSS806NE                                                      *
* BSS816NW                                                      *
* BSD816SN                                                      *
* BSD840N  (L3 modeled as single only)                          *
*                                                               *
*   OptiMOS2 20V SLL, (2.5 V rated)                             *
* BSC019N02KS                                                   *
* BSC026N02KS                                                   *
* BSC046N02KS                                                   *
* BSR202N                                                       *
* BSL202SN                                                      *
* BSO330N02K                                                    *
* BSL205N  (L3 modeled as single only)                          *
* BSL207N  (L3 modeled as single only)                          *
* BSL214N  (L3 modeled as single only)                          *
* BSS205N                                                       *
* BSS214N                                                       *
* BSS214NW                                                      *
* BSD235N  (L3 modeled as single only)                          *
* BSD214SN                                                      *
*                                                               *
*****************************************************************
* thermal nodes of level 3 models:                              *
*                                                               *
*  .SUBCKT IPP05N03LA drain gate source Tj Tcase                *
*  Tj :    potential=temperature (in ?C) at junction (typically *
*          not connected)                                       *
*  Tcase : node where the boundary contition - external heat    *
*          sinks etc - have to be connected (ideal heat sink    *
*          can be modeled by using a voltage source stating the *
*          ambient temperature in ?C between Tcase and ground.  *
*                                                               *
*****************************************************************

.SUBCKT S3_20_s_var dd g s0 Tj PARAMS: a=1 dVth=0 dR=0 dgfs=0 Inn=1 Unn=1 Rmax=1
+gmin=1 Rs=1 Rp=1 dC=0 Rm=1u heat=0

.PARAM  Fm=0.07      Fn=0.5       kbq=85.8u
.PARAM  c=1          muc=0.0      Vth0=1.628   auth=1.481m   al=0.5
.PARAM  UT=100m      ab=24.7m     ab2=0        lB=-23        UB=25.37

.PARAM  b0=128.9     p0=2.714     p1=-6.3m     p2=13u

.PARAM  Rd=8.3m      nmu=2.7      Tref=298     T0=273       lnIsj=-22.24
.PARAM  ndi=1.218    Rdi=6.36m    nmu2=0.032   ta=3n        td=20n
.PARAM  Rf=0.6       nmu3=1.5

.PARAM  f1=380p      f2=400p      f3=830p      U0=3       nc=0.5    nd=0.5
.PARAM  g1=11        bb=0.4       remp=5p      f2r=100p

.PARAM  Vmin=1.378   Vmax=1.878  dCmax=0.33
.PARAM  Vth={Vth0+(Vmax-Vth0)*limit(dVth,0,1)-(Vmin-Vth0)*limit(dVth,-1,0)}
.PARAM  q0={b0*((T0/Tref)**nmu3)*a}
.PARAM  q1={(Unn-Inn*Rs-Vth0)*q0}
.PARAM  q2={(Fm*SQRT(0.4)-c)*Inn*q0}
.PARAM  Rlim={(q1+2*q2*Rmax-SQRT(q1**2+4*q2))/(2*q2)}
.PARAM  dRd={Rd/a+if(dVth==0,limit(dR,0,1)*max(Rlim-Rd/a-Rs-Rp,0),0)}
.PARAM  bm={c/((1/gmin-Rs)**2*Inn*a*(T0/Tref)**nmu3)}
.PARAM  bet={b0+(b0-bm)*if(dR==0,if(dVth==0,limit(dgfs,-1,0),0),0)}
.PARAM  dC1={1+dCmax*limit(dC,0,1)}
.PARAM  dC2={1+dCmax*limit(dC,0,1)*1.5}

.PARAM  Cox={f1*a*dC2}
.PARAM  Cox1={remp*SQRT(a)*dC2}
.PARAM  Cds0={(f2*a+f2r*SQRT(a))*dC1}
.PARAM  Cgs0={f3*a*dC1}
.PARAM  dRdi={Rdi/a}

.FUNC  I0(Uee,p,pp,z1,cc)  {if(Uee>pp,(Uee-cc*z1)*z1,p*(pp-p)/cc*exp((Uee-pp)/p))}
.FUNC  Ig(Uds,T,p,Uee,cc)  {bet*(T0/T)**nmu3*I0(Uee,p,min(2*p,p+cc*Uds),min(Uds,Uee/(2*cc)),cc)}
.FUNC  J(d,g,T,da,s)
+ {a*s*((Ig(da,T,(p0+(p1+p2*T)*T)*kbq*T,g-Vth+auth*(T-Tref)+Fm*da**Fn,c*(T/Tref)**muc)+exp(min(lB+(d-UB-ab*(T-Tref))/UT,25))))}

.FUNC  Idiode(Usd,Tj,Iss) {exp(min(log(Iss)+Usd/(ndi*kbq*Tj),7))-Iss}
.FUNC  Idiod(Usd,Tj)      {a*Idiode(Usd,Tj,exp(min(lnIsj+(Tj/Tref-1)*1.12/(ndi*kbq*Tj),7))*(Tj/Tref)**1)}

E_Edg     d   ox  VALUE {max(V(d,g),-bb)-(1/(g1*(1-nc))*((1/(1+g1*max(V(d,g)+bb,0)))**(nc-1)-(1/(1+g1*bb))**(nc-1)))}
C_Cdg    ox    g  {Cox}
Vx        d   ox1 0
C_Cdg1   ox1   g  {Cox1}

E_Eds     d edep  VALUE {(V(d,s)-I(V_sense3)/Cds0)}
C_Cds  edep    s  {Cds0}

C_Cgs   g    s   {Cgs0}

G_chan    d    s  VALUE={J(V(d,s),V(g,s),T0+limit(V(Tj),-200,300),(SQRT(1+4*al*abs(V(d,s)))-1)/2/al,sgn(V(d,s)))}
G_RMos   d1    d  VALUE={V(d1,d)/(Rf*dRd+(1-Rf)*dRd*((limit(V(Tj),-200,999)+T0)/Tref)**nmu)}
V_sense  dd   d1  0
G_diode   s   d3  VALUE={Idiod(V(s,d3),T0+limit(V(Tj),-200,499))}
G_Rdio   d2   d1  VALUE={V(d2,d1)/(dRdi*((limit(V(Tj),-200,999)+T0)/Tref)**nmu2)}
V_sense2 d2   d3  0

L_L001    a    c  {td/(ta+td)}
R_R001    a    b  {1/ta}
V_sense3  c    0  0
E_E001    b    0  VALUE {I(V_sense2)}
E_E002    e    0  VALUE {Cds0*1/(1-nd)*U0**nd*(limit(U0+V(d1,s),0,2*UB))**(1-nd)}
R_R002    e    c  1
R_R003    a    0  500Meg

R1        g    s  1G
Rd01      d    s  500Meg
Rd02     d2    s  500Meg
Rd03     d1    d  1k

Rmet      s    s0 {Rm}

G_TH      0   Tj  VALUE =
+{(LIMIT(I(V_sense2)*V(d1,s)+(V(s,s0)**2)/Rm+(I(V_sense)-I(V_sense2))*V(d1,d)+
+(I(V_sense)-I(V_sense2)-I(E_Edg)-I(Vx)-I(E_Eds))*V(d,s),-10k,100k))}

.ENDS

**********

.SUBCKT S3_20_u_var dd g s0 Tj PARAMS: a=1 dVth=0 dR=0 dgfs=0 Inn=1 Unn=1 Rmax=1
+gmin=1 Rs=1 Rp=1 dC=0 Rm=1u heat=0

.PARAM  Fm=0.025     Fn=0.5       kbq=85.8u
.PARAM  c=0.75       muc=0.0      Vth0=1.17    auth=1.36m    al=0.001
.PARAM  UT=100m      ab=22m       ab2=0        lB=-23        UB=24.2

.PARAM  b0=180       p0=2.61      p1=-6.93m    p2=12.5u

.PARAM  Rd=6.642m    nmu=3.045    Tref=298     T0=273       lnIsj=-22.24
.PARAM  ndi=1.218    Rdi=6.36m    nmu2=0.032   ta=3n        td=20n
.PARAM  Rf=0.723     nmu3=1.5

.PARAM  f1=700p      f2=400p      f3=970p      U0=3         nc=0.5    nd=0.5
.PARAM  g1=21        bb=0.11      remp=4p      f2r=100p

.PARAM  Vmin=0.97    Vmax=1.37    dCmax=0.33
.PARAM  Vth={Vth0+(Vmax-Vth0)*limit(dVth,0,1)-(Vmin-Vth0)*limit(dVth,-1,0)}
.PARAM  q0={b0*((T0/Tref)**nmu3)*a}
.PARAM  q1={(Unn-Inn*Rs-Vth0)*q0}
.PARAM  q2={(Fm*SQRT(0.4)-c)*Inn*q0}
.PARAM  Rlim={(q1+2*q2*Rmax-SQRT(q1**2+4*q2))/(2*q2)}
.PARAM  dRd={Rd/a+if(dVth==0,limit(dR,0,1)*max(Rlim-Rd/a-Rs-Rp,0),0)}
.PARAM  bm={c/((1/gmin-Rs)**2*Inn*a*(T0/Tref)**nmu3)}
.PARAM  bet={b0+(b0-bm)*if(dR==0,if(dVth==0,limit(dgfs,-1,0),0),0)}
.PARAM  dC1={1+dCmax*limit(dC,0,1)}
.PARAM  dC2={1+dCmax*limit(dC,0,1)*1.5}

.PARAM  Cox={f1*a*dC2}
.PARAM  Cox1={remp*SQRT(a)*dC2}
.PARAM  Cds0={(f2*a+f2r*SQRT(a))*dC1}
.PARAM  Cgs0={f3*a*dC1}
.PARAM  dRdi={Rdi/a}

.FUNC  I0(Uee,p,pp,z1,cc)  {if(Uee>pp,(Uee-cc*z1)*z1,p*(pp-p)/cc*exp((Uee-pp)/p))}
.FUNC  Ig(Uds,T,p,Uee,cc)  {bet*(T0/T)**nmu3*I0(Uee,p,min(2*p,p+cc*Uds),min(Uds,Uee/(2*cc)),cc)}
.FUNC  J(d,g,T,da,s)
+ {a*s*((Ig(da,T,(p0+(p1+p2*T)*T)*kbq*T,g-Vth+auth*(T-Tref)+Fm*da**Fn,c*(T/Tref)**muc)+exp(min(lB+(d-UB-ab*(T-Tref))/UT,25))))}

.FUNC  Idiode(Usd,Tj,Iss) {exp(min(log(Iss)+Usd/(ndi*kbq*Tj),7))-Iss}
.FUNC  Idiod(Usd,Tj)      {a*Idiode(Usd,Tj,exp(min(lnIsj+(Tj/Tref-1)*1.12/(ndi*kbq*Tj),7))*(Tj/Tref)**1)}

E_Edg     d   ox  VALUE {max(V(d,g),-bb)-(1/(g1*(1-nc))*((1/(1+g1*max(V(d,g)+bb,0)))**(nc-1)-(1/(1+g1*bb))**(nc-1)))}
C_Cdg    ox    g  {Cox}
Vx        d   ox1 0
C_Cdg1   ox1   g  {Cox1}

E_Eds     d edep  VALUE {(V(d,s)-I(V_sense3)/Cds0)}
C_Cds  edep    s  {Cds0}

C_Cgs   g    s   {Cgs0}

G_chan    d    s  VALUE={J(V(d,s),V(g,s),T0+limit(V(Tj),-200,300),(SQRT(1+4*al*abs(V(d,s)))-1)/2/al,sgn(V(d,s)))}
G_RMos   d1    d  VALUE={V(d1,d)/(Rf*dRd+(1-Rf)*dRd*((limit(V(Tj),-200,999)+T0)/Tref)**nmu)}
V_sense  dd   d1  0
G_diode   s   d3  VALUE={Idiod(V(s,d3),T0+limit(V(Tj),-200,499))}
G_Rdio   d2   d1  VALUE={V(d2,d1)/(dRdi*((limit(V(Tj),-200,999)+T0)/Tref)**nmu2)}
V_sense2 d2   d3  0

L_L001    a    c  {td/(ta+td)}
R_R001    a    b  {1/ta}
V_sense3  c    0  0
E_E001    b    0  VALUE {I(V_sense2)}
E_E002    e    0  VALUE {Cds0*1/(1-nd)*U0**nd*(limit(U0+V(d1,s),0,2*UB))**(1-nd)}
R_R002    e    c  1
R_R003    a    0  500Meg

R1        g    s  1G
Rd01      d    s  500Meg
Rd02     d2    s  500Meg
Rd03     d1    d  1k

Rmet      s    s0 {Rm}

G_TH      0   Tj  VALUE =
+{(LIMIT(I(V_sense2)*V(d1,s)+(V(s,s0)**2)/Rm+(I(V_sense)-I(V_sense2))*V(d1,d)+
+(I(V_sense)-I(V_sense2)-I(E_Edg)-I(Vx)-I(E_Eds))*V(d,s),-10k,100k))}

.ENDS

****************************************************************************************************

.SUBCKT BSC019N02KS drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=1n Lg=3n

.PARAM Rs=482u      Rg=1.9       Rd=50u       Rm=400u
.PARAM Inn=50       Unn=4.5      Rmax=1.95m   gmin=100

.PARAM act=11.03

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {2.39m+limit(Zthtype,0,1)*878.98u}
Rth2  t1      t2              {32.13m+limit(Zthtype,0,1)*11.89m}
Rth3  t2      t3              {123.34m+limit(Zthtype,0,1)*39.62m}
Rth4  t3      t4              {129.59m+limit(Zthtype,0,1)*217.61m}
Rth5  t4      Tcase           {239.83m+limit(Zthtype,0,1)*402.72m}
Cth1  Tj      0               76.781u
Cth2  t1      0               435.464u
Cth3  t2      0               2.72m
Cth4  t3      0               1.944m
Cth5  t4      0               47.017m
Cth6  Tcase   0               30m

.ENDS

**********

.SUBCKT BSC026N02KS drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=1n Lg=3n

.PARAM Rs=361u      Rg=1.5       Rd=50u       Rm=190u
.PARAM Inn=50       Unn=4.5      Rmax=2.6m    gmin=57

.PARAM act=6.77

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {3.89m+limit(Zthtype,0,1)*1.44m}
Rth2  t1      t2              {51.65m+limit(Zthtype,0,1)*19.11m}
Rth3  t2      t3              {186.29m+limit(Zthtype,0,1)*64.8m}
Rth4  t3      t4              {211.13m+limit(Zthtype,0,1)*300.99m}
Rth5  t4      Tcase           {313.61m+limit(Zthtype,0,1)*447.09m}
Cth1  Tj      0               47.127u
Cth2  t1      0               270.877u
Cth3  t2      0               1.834m
Cth4  t3      0               1.193m
Cth5  t4      0               33.557m
Cth6  Tcase   0               35m

.ENDS

**********

.SUBCKT BSC046N02KS drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=1n Lg=3n

.PARAM Rs=254u      Rg=1.9       Rd=50u       Rm=83u
.PARAM Inn=50       Unn=4.5      Rmax=4.6m    gmin=42

.PARAM act=3.55

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {7.41m+limit(Zthtype,0,1)*2.75m}
Rth2  t1      t2              {96.23m+limit(Zthtype,0,1)*35.61m}
Rth3  t2      t3              {343.77m+limit(Zthtype,0,1)*124.41m}
Rth4  t3      t4              {402.63m+limit(Zthtype,0,1)*574.54m}
Rth5  t4      Tcase           {417.25m+limit(Zthtype,0,1)*595.4m}
Cth1  Tj      0               24.712u
Cth2  t1      0               145.39u
Cth3  t2      0               1.004m
Cth4  t3      0               625.577u
Cth5  t4      0               25.139m
Cth6  Tcase   0               40m

.ENDS

**********

.SUBCKT BSR202N drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=0.8n Ld=1n Lg=3n

.PARAM Rs=4.48m     Rg=1.9       Rd=500u      Rm=4m
.PARAM Inn=3.8      Unn=4.5      Rmax=23m     gmin=8

.PARAM act=0.991

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {26.69m+limit(Zthtype,0,1)*9.88m}
Rth2  t1      t2              {321.74m+limit(Zthtype,0,1)*119.08m}
Rth3  t2      t3              {1.48+limit(Zthtype,0,1)*451.64m}
Rth4  t3      t4              {42.78+limit(Zthtype,0,1)*37.73}
Rth5  t4      Tcase           {30.33+limit(Zthtype,0,1)*26.75}
Cth1  Tj      0               6.864u
Cth2  t1      0               43.483u
Cth3  t2      0               141.188u
Cth4  t3      0               1.166m
Cth5  t4      0               9.189m
Cth6  Tcase   0               5m

.ENDS

**********

.SUBCKT BSL202SN drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=1n Lg=3n

.PARAM Rs=5.48m     Rg=1.9       Rd=140u      Rm=5m
.PARAM Inn=3.8      Unn=4.5      Rmax=24m     gmin=8

.PARAM act=0.991

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {26.56m+limit(Zthtype,0,1)*9.83m}
Rth2  t1      t2              {320.25m+limit(Zthtype,0,1)*118.52m}
Rth3  t2      t3              {1.93+limit(Zthtype,0,1)*459.59m}
Rth4  t3      t4              {10.69+limit(Zthtype,0,1)*11.84}
Rth5  t4      Tcase           {11.67+limit(Zthtype,0,1)*12.93}
Cth1  Tj      0               6.898u
Cth2  t1      0               43.687u
Cth3  t2      0               145.816u
Cth4  t3      0               635.538u
Cth5  t4      0               7m

.ENDS

*********************

.SUBCKT BSL205N drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=7.13m     Rg=4.9       Rd=550u      Rm=600u
.PARAM Inn=2.5      Unn=4.5      Rmax=50m     gmin=4.6

.PARAM act=0.361

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {72.91m+limit(Zthtype,0,1)*26.98m}
Rth2  t1      t2              {796.9m+limit(Zthtype,0,1)*294.92m}
Rth3  t2      t3              {4.09+limit(Zthtype,0,1)*1.28}
Rth4  t3      t4              {19.18+limit(Zthtype,0,1)*7.1}
Rth5  t4      Tcase           {49.02+limit(Zthtype,0,1)*18.14}
Cth1  Tj      0               2.513u
Cth2  t1      0               6.514u
Cth3  t2      0               50.593u
Cth4  t3      0               214.138u
Cth5  t4      0               1.193m
Cth6  Tcase   0               5m

.ENDS

**********

.SUBCKT BSS205N drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=8.11m     Rg=4.9       Rd=550u      Rm=600u
.PARAM Inn=2.5      Unn=4.5      Rmax=50m     gmin=4.6

.PARAM act=0.361

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {72.91m+limit(Zthtype,0,1)*26.98m}
Rth2  t1      t2              {796.9m+limit(Zthtype,0,1)*294.92m}
Rth3  t2      t3              {4.09+limit(Zthtype,0,1)*1.28}
Rth4  t3      t4              {11.88+limit(Zthtype,0,1)*11.21}
Rth5  t4      Tcase           {56.78+limit(Zthtype,0,1)*53.57}
Cth1  Tj      0               2.513u
Cth2  t1      0               6.514u
Cth3  t2      0               50.593u
Cth4  t3      0               389.69u
Cth5  t4      0               600u
Cth6  Tcase   0               6m

.ENDS

**********

.SUBCKT BSL207N drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1.5n Ld=0.5n Lg=2n

.PARAM Rs=25.7m     Rg=4.9       Rd=550u      Rm=1m
.PARAM Inn=2.05     Unn=4.5      Rmax=70m     gmin=3.9

.PARAM act=0.361

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {72.91m+limit(Zthtype,0,1)*26.98m}
Rth2  t1      t2              {796.9m+limit(Zthtype,0,1)*294.92m}
Rth3  t2      t3              {4.09+limit(Zthtype,0,1)*1.28}
Rth4  t3      t4              {19.18+limit(Zthtype,0,1)*7.1}
Rth5  t4      Tcase           {49.02+limit(Zthtype,0,1)*18.14}
Cth1  Tj      0               2.513u
Cth2  t1      0               6.514u
Cth3  t2      0               50.593u
Cth4  t3      0               214.138u
Cth5  t4      0               1.193m
Cth6  Tcase   0               5m

.ENDS

**********

.SUBCKT BSL214N drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=13.05m    Rg=11.3      Rd=550u      Rm=600u
.PARAM Inn=1.5      Unn=4.5      Rmax=140m    gmin=2.1

.PARAM act=0.122

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {215.74m+limit(Zthtype,0,1)*79.85m}
Rth2  t1      t2              {2+limit(Zthtype,0,1)*734.81m}
Rth3  t2      t3              {7.66+limit(Zthtype,0,1)*3.92}
Rth4  t3      t4              {33.24+limit(Zthtype,0,1)*11.85}
Rth5  t4      Tcase           {59.19+limit(Zthtype,0,1)*21.11}
Cth1  Tj      0               849.255n
Cth2  t1      0               2.681u
Cth3  t2      0               16.282u
Cth4  t3      0               72.252u
Cth5  t4      0               992.905u
Cth6  Tcase   0               5m

.ENDS

**********

.SUBCKT BSS214N drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=15.03m    Rg=11.3      Rd=550u      Rm=600u
.PARAM Inn=1.5      Unn=4.5      Rmax=140m    gmin=2.1

.PARAM act=0.122

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {215.74m+limit(Zthtype,0,1)*79.85m}
Rth2  t1      t2              {2+limit(Zthtype,0,1)*734.81m}
Rth3  t2      t3              {7.66+limit(Zthtype,0,1)*3.92}
Rth4  t3      t4              {11.87+limit(Zthtype,0,1)*9.08}
Rth5  t4      Tcase           {59.17+limit(Zthtype,0,1)*45.27}
Cth1  Tj      0               849.255n
Cth2  t1      0               2.681u
Cth3  t2      0               16.282u
Cth4  t3      0               223.105u
Cth5  t4      0               601.844u
Cth6  Tcase   0               6m

.ENDS

**********

.SUBCKT BSS214NW drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=11.28m    Rg=11.3      Rd=800u      Rm=600u
.PARAM Inn=1.5      Unn=4.5      Rmax=140m    gmin=2.1

.PARAM act=0.122

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {215.74m+limit(Zthtype,0,1)*79.85m}
Rth2  t1      t2              {2+limit(Zthtype,0,1)*734.81m}
Rth3  t2      t3              {7.66+limit(Zthtype,0,1)*3.92}
Rth4  t3      t4              {27.56+limit(Zthtype,0,1)*23.9}
Rth5  t4      Tcase           {39.6+limit(Zthtype,0,1)*34.33}
Cth1  Tj      0               849.255n
Cth2  t1      0               2.681u
Cth3  t2      0               15.316u
Cth4  t3      0               326.936u
Cth5  t4      0               1.111m
Cth6  Tcase   0               1.8m

.ENDS

**********

.SUBCKT BSD214SN drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=16.37m    Rg=11.3      Rd=240u      Rm=600u
.PARAM Inn=1.5      Unn=4.5      Rmax=140m    gmin=2.1

.PARAM act=0.122

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {215.74m+limit(Zthtype,0,1)*79.85m}
Rth2  t1      t2              {2+limit(Zthtype,0,1)*734.81m}
Rth3  t2      t3              {7.66+limit(Zthtype,0,1)*3.92}
Rth4  t3      t4              {31.58+limit(Zthtype,0,1)*12.05}
Rth5  t4      Tcase           {59.17+limit(Zthtype,0,1)*22.59}
Cth1  Tj      0               849.255n
Cth2  t1      0               2.681u
Cth3  t2      0               16.282u
Cth4  t3      0               121.071u
Cth5  t4      0               493.707u
Cth6  Tcase   0               2m

.ENDS

**********

.SUBCKT BSD235N drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=46.66m    Rg=10.5      Rd=960u      Rm=2m
.PARAM Inn=0.95     Unn=4.5      Rmax=350m    gmin=1.1

.PARAM act=0.053

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {496.62m+limit(Zthtype,0,1)*183.79m}
Rth2  t1      t2              {3.8+limit(Zthtype,0,1)*1.41}
Rth3  t2      t3              {12.41+limit(Zthtype,0,1)*9.31}
Rth4  t3      t4              {43.34+limit(Zthtype,0,1)*8.85}
Rth5  t4      Tcase           {50+limit(Zthtype,0,1)*10.2}
Cth1  Tj      0               368.939n
Cth2  t1      0               641.8n
Cth3  t2      0               4.643u
Cth4  t3      0               141.063u
Cth5  t4      0               491.973u
Cth6  Tcase   0               2m

.ENDS

**********

.SUBCKT BSO330N02K drain1 gate1 source1 drain1a drain2 gate2 source2 drain2a Tj1 Tsolder_joint1 Tj2
 + Tsolder_joint2 PARAMS: dVth1=0 dVth2=0 dRdson1=0 dRdson2=0 dgfs1=0 dgfs2=0 dC1=0 dC2=0 Zthtype=0 Ls=0 Ld=0 Lg=0

.PARAM Rs=5.31m     Rg=0.8       Rd=353u      Rm=260u
.PARAM Inn=6.6      Unn=4.5      Rmax=30m     gmin=6
.PARAM RRf=500m     Rrbond=3     Rtb=80.3     g2=1
.PARAM act=0.63

.FUNC   Pb(I,dT,Rb)  {Rb/(2*Rtb)*(I-limit(dT/(max(I,1n)*Rb)+RRf*I*g2,0,I))**2}

X1  d1a ga sa Tj1 S3_20_s_var PARAMS: a={act} dVth={dVth1} dR={dRdson1} dgfs={dgfs1} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC1} Rm={Rm} heat=0
X2  d1b gb sb Tj2 S3_20_s_var PARAMS: a={act} dVth={dVth2} dR={dRdson2} dgfs={dgfs2} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC2} Rm={Rm} heat=0
Rg1    g1a     ga    {Rg}
Lg1    gate1   g1a   {Lg*if(dgfs1==99,0,1)}
Gsa1   s1a     sa    VALUE={V(s1a,sa)/(Rs*(1+(limit(V(Tj1),-200,999)-25)*4m)-Rm)}
Rsa1   source1 sa    1Meg
Ls1    source1 s1a   {Ls*if(dgfs1==99,0,1)}
Rda1   d1a     d2a   {Rd*2}
Ld1    drain1  d2a   {Ld*2*if(dgfs1==99,0,1)}
Rdb1   d1a     d3a   {Rd*2}
Ld1a   drain1a d3a   {Ld*2*if(dgfs1==99,0,1)}

Rg2    g1b     gb    {Rg}
Lg2    gate2   g1b   {Lg*if(dgfs1==99,0,1)}
Gsa2   s1b     sb    VALUE={V(s1b,sb)/(Rs*(1+(limit(V(Tj2),-200,999)-25)*4m)-Rm)}
Rsa2   source2 sb    1Meg
Ls2    source2 s1b   {Ls*if(dgfs1==99,0,1)}
Rda2   d1b     d2b   {Rd*2}
Ld2    drain2  d2b   {Ld*2*if(dgfs1==99,0,1)}
Rdb2   d1b     d3b   {Rd*2}
Ld2a   drain2a d3b   {Ld*2*if(dgfs1==99,0,1)}

G_TH1 0 Tb1 VALUE ={Pb(abs(I(Ls1)),V(Tj1,Tsolder_joint1),Rrbond*(1+(limit((V(Tb1)+V(Tj1))/2,-200,999)-25)*4m))}
G_TH2 0 Tb2 VALUE ={Pb(abs(I(Ls2)),V(Tj2,Tsolder_joint2),Rrbond*(1+(limit((V(Tb2)+V(Tj2))/2,-200,999)-25)*4m))}

Rthb1  Tb1      Tj1              {Rtb}
Rth11  Tj1      t1a              {41.78m+limit(Zthtype,0,1)*15.46m}
Rth21  t1a      t2a              {484.69m+limit(Zthtype,0,1)*179.38m}
Rth31  t2a      t3a              {3.91+limit(Zthtype,0,1)*722.2m}
Rth41  t3a      t4a              {10+limit(Zthtype,0,1)*5.86}
Rth51  t4a      Tsolder_joint1   {33+limit(Zthtype,0,1)*9}
Cth11  Tj1      0                4.385u
Cth21  t1a      0                28.865u
Cth31  t2a      0                146.538u
Cth41  t3a      0                3.774m
Cth51  t4a      0                23.333m

Rthb2  Tb2      Tj2              {Rtb}
Rth12  Tj2      t1b              {41.78m+limit(Zthtype,0,1)*15.46m}
Rth22  t1b      t2b              {484.69m+limit(Zthtype,0,1)*179.38m}
Rth32  t2b      t3b              {3.91+limit(Zthtype,0,1)*722.2m}
Rth42  t3b      t4b              {10+limit(Zthtype,0,1)*5.86}
Rth52  t4b      Tsolder_joint2   {33+limit(Zthtype,0,1)*9}
Cth12  Tj1      0                4.385u
Cth22  t1b      0                28.865u
Cth32  t2b      0                146.538u
Cth42  t3b      0                3.774m
Cth52  t4b      0                23.333m

Rthk1  Tj1      e1               300
Rthk2  Tj2      e1               300
Rthk3  t3a      e2               100
Rthk4  t3b      e2               100
Cthk1  e1       0                4m
Cthk2  e2       0                3m

.ENDS

**************************************************************************************

.SUBCKT BSR802N drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=0.8n Ld=1n Lg=3n

.PARAM Rs=4.53m     Rg=2.3       Rd=500u      Rm=1m
.PARAM Inn=3.7      Unn=2.5      Rmax=23m     gmin=9.2

.PARAM act=0.991

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {26.69m+limit(Zthtype,0,1)*9.88m}
Rth2  t1      t2              {321.74m+limit(Zthtype,0,1)*119.08m}
Rth3  t2      t3              {1.48+limit(Zthtype,0,1)*451.64m}
Rth4  t3      t4              {42.78+limit(Zthtype,0,1)*37.73}
Rth5  t4      Tcase           {30.33+limit(Zthtype,0,1)*26.75}
Cth1  Tj      0               6.864u
Cth2  t1      0               43.483u
Cth3  t2      0               141.188u
Cth4  t3      0               1.166m
Cth5  t4      0               9.189m
Cth6  Tcase   0               5m

.ENDS

**********

.SUBCKT BSL802SN drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=0.5n Ld=0.5n Lg=1n

.PARAM Rs=5.54m     Rg=2.3       Rd=206u      Rm=1m
.PARAM Inn=7.5      Unn=2.5      Rmax=22m     gmin=12.7

.PARAM act=0.991

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {26.56m+limit(Zthtype,0,1)*9.83m}
Rth2  t1      t2              {320.25m+limit(Zthtype,0,1)*118.52m}
Rth3  t2      t3              {1.93+limit(Zthtype,0,1)*459.59m}
Rth4  t3      t4              {10.69+limit(Zthtype,0,1)*11.84}
Rth5  t4      Tcase           {11.67+limit(Zthtype,0,1)*12.93}
Cth1  Tj      0               6.898u
Cth2  t1      0               43.687u
Cth3  t2      0               145.816u
Cth4  t3      0               635.538u
Cth5  t4      0               7m
Cth6  Tcase   0               1m

.ENDS

**********

.SUBCKT BSL806N drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=7.13m     Rg=4.4       Rd=550u      Rm=600u
.PARAM Inn=2.3      Unn=2.5      Rmax=57m     gmin=4.4

.PARAM act=0.361

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {72.91m+limit(Zthtype,0,1)*26.98m}
Rth2  t1      t2              {796.9m+limit(Zthtype,0,1)*294.92m}
Rth3  t2      t3              {4.09+limit(Zthtype,0,1)*1.28}
Rth4  t3      t4              {19.18+limit(Zthtype,0,1)*7.1}
Rth5  t4      Tcase           {49.02+limit(Zthtype,0,1)*18.14}
Cth1  Tj      0               2.513u
Cth2  t1      0               6.514u
Cth3  t2      0               50.593u
Cth4  t3      0               214.138u
Cth5  t4      0               1.193m
Cth6  Tcase   0               5m

.ENDS

**********

.SUBCKT BSS806N drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=8.11m     Rg=4.4       Rd=550u      Rm=600u
.PARAM Inn=2.3      Unn=2.5      Rmax=57m     gmin=4.4

.PARAM act=0.361

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {72.91m+limit(Zthtype,0,1)*26.98m}
Rth2  t1      t2              {796.9m+limit(Zthtype,0,1)*294.92m}
Rth3  t2      t3              {4.09+limit(Zthtype,0,1)*1.28}
Rth4  t3      t4              {11.88+limit(Zthtype,0,1)*11.21}
Rth5  t4      Tcase           {56.78+limit(Zthtype,0,1)*53.57}
Cth1  Tj      0               2.513u
Cth2  t1      0               6.514u
Cth3  t2      0               50.593u
Cth4  t3      0               389.69u
Cth5  t4      0               600u
Cth6  Tcase   0               6m

.ENDS

**********

.SUBCKT BSS806NE drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=8.11m     Rg=4.4       Rd=550u      Rm=600u
.PARAM Inn=2.3      Unn=2.5      Rmax=57m     gmin=4.4

.PARAM act=0.361

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {72.91m+limit(Zthtype,0,1)*26.98m}
Rth2  t1      t2              {796.9m+limit(Zthtype,0,1)*294.92m}
Rth3  t2      t3              {4.09+limit(Zthtype,0,1)*1.28}
Rth4  t3      t4              {11.88+limit(Zthtype,0,1)*11.21}
Rth5  t4      Tcase           {56.78+limit(Zthtype,0,1)*53.57}
Cth1  Tj      0               2.513u
Cth2  t1      0               6.514u
Cth3  t2      0               50.593u
Cth4  t3      0               389.69u
Cth5  t4      0               600u
Cth6  Tcase   0               6m

.ENDS

**********

.SUBCKT BSS816NW drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=11.28m    Rg=10        Rd=800u      Rm=600u
.PARAM Inn=1.4      Unn=2.5      Rmax=160m    gmin=2

.PARAM act=0.122

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {215.74m+limit(Zthtype,0,1)*79.85m}
Rth2  t1      t2              {2+limit(Zthtype,0,1)*734.81m}
Rth3  t2      t3              {7.66+limit(Zthtype,0,1)*3.92}
Rth4  t3      t4              {27.56+limit(Zthtype,0,1)*23.9}
Rth5  t4      Tcase           {39.6+limit(Zthtype,0,1)*34.33}
Cth1  Tj      0               849.255n
Cth2  t1      0               2.681u
Cth3  t2      0               15.316u
Cth4  t3      0               326.936u
Cth5  t4      0               1.111m
Cth6  Tcase   0               1.8m

.ENDS

**********

.SUBCKT BSD816SN drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=16.37m    Rg=10        Rd=240u      Rm=600u
.PARAM Inn=1.4      Unn=2.5      Rmax=160m    gmin=2

.PARAM act=0.122

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {215.74m+limit(Zthtype,0,1)*79.85m}
Rth2  t1      t2              {2+limit(Zthtype,0,1)*734.81m}
Rth3  t2      t3              {7.66+limit(Zthtype,0,1)*3.92}
Rth4  t3      t4              {31.58+limit(Zthtype,0,1)*12.05}
Rth5  t4      Tcase           {59.17+limit(Zthtype,0,1)*22.59}
Cth1  Tj      0               849.255n
Cth2  t1      0               2.681u
Cth3  t2      0               16.282u
Cth4  t3      0               121.071u
Cth5  t4      0               493.707u
Cth6  Tcase   0               2m

.ENDS

**********

.SUBCKT BSD840N drain gate source Tj Tcase PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Zthtype=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=46.66m    Rg=10.5      Rd=960u      Rm=2m
.PARAM Inn=0.88     Unn=2.5      Rmax=400m    gmin=1

.PARAM act=0.053

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}
RLs   source s1   10
RLg   gate   g1   10
RLd   drain  d2   10

Rth1  Tj      t1              {496.62m+limit(Zthtype,0,1)*183.79m}
Rth2  t1      t2              {3.8+limit(Zthtype,0,1)*1.41}
Rth3  t2      t3              {12.41+limit(Zthtype,0,1)*9.31}
Rth4  t3      t4              {43.34+limit(Zthtype,0,1)*8.85}
Rth5  t4      Tcase           {50+limit(Zthtype,0,1)*10.2}
Cth1  Tj      0               368.939n
Cth2  t1      0               641.8n
Cth3  t2      0               4.643u
Cth4  t3      0               141.063u
Cth5  t4      0               491.973u
Cth6  Tcase   0               2m

.ENDS

***************************************************************

.SUBCKT BSC019N02KS_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=1n Lg=3n

.PARAM Rs=482u      Rg=1.9       Rd=50u       Rm=400u
.PARAM Inn=50       Unn=4.5      Rmax=1.95m   gmin=100
.PARAM act=11.03

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSC026N02KS_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=1n Lg=3n

.PARAM Rs=361u      Rg=1.5       Rd=50u       Rm=190u
.PARAM Inn=50       Unn=4.5      Rmax=2.6m    gmin=57
.PARAM act=6.77

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSC046N02KS_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=1n Lg=3n

.PARAM Rs=254u      Rg=1.9       Rd=50u       Rm=83u
.PARAM Inn=50       Unn=4.5      Rmax=4.6m    gmin=42
.PARAM act=3.55

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSR202N_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=0.8n Ld=1n Lg=3n

.PARAM Rs=4.48m     Rg=1.9       Rd=500u      Rm=4m
.PARAM Inn=3.8      Unn=4.5      Rmax=23m     gmin=8
.PARAM act=0.991

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSL202SN_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=1n Lg=3n

.PARAM Rs=5.48m     Rg=1.9       Rd=140u      Rm=5m
.PARAM Inn=3.8      Unn=4.5      Rmax=24m     gmin=8
.PARAM act=0.991

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSL205N_L1 drain1 gate1 source1 drain2 gate2 source2
  + PARAMS: dVth1=0 dVth2=0 dRdson1=0 dRdson2=0 dgfs1=0 dgfs2=0 dC1=0 dC2=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=7.13m     Rg=4.9       Rd=550u      Rm=600u
.PARAM Inn=2.5      Unn=4.5      Rmax=50m     gmin=4.6
.PARAM act=0.361

X1      d1a      ga    sa    Tj   S3_20_s_var PARAMS: a={act} dVth={dVth1} dR={dRdson1} dgfs={dgfs1}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC1} Rm={Rm}
Rga     g1a      ga     {Rg}
Lga     gate1    g1a    {Lg*if(dgfs1==99,0,1)}
Gsa     s1a      sa     VALUE={V(s1a,sa)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsa     source1  s1a    {Ls*if(dgfs1==99,0,1)}
Rda1    d1a      d2a    {Rd}
Lda1    drain1   d2a    {Ld*if(dgfs1==99,0,1)}

X2      d1b      gb    sb    Tj   S3_20_s_var PARAMS: a={act} dVth={dVth2} dR={dRdson2} dgfs={dgfs2}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC2} Rm={Rm}
Rgb     g1b      gb     {Rg}
Lgb     gate2    g1b    {Lg*if(dgfs2==99,0,1)}
Gsb     s1b      sb     VALUE={V(s1b,sb)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsb     source2  s1b    {Ls*if(dgfs2==99,0,1)}
Rdb1    d1b      d2b    {Rd}
Ldb1    drain2   d2b    {Ld*if(dgfs2==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSS205N_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=8.11m     Rg=4.9       Rd=550u      Rm=600u
.PARAM Inn=2.5      Unn=4.5      Rmax=50m     gmin=4.6
.PARAM act=0.361

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSL207N_L1 drain1 gate1 source1 drain2 gate2 source2
  + PARAMS: dVth1=0 dVth2=0 dRdson1=0 dRdson2=0 dgfs1=0 dgfs2=0 dC1=0 dC2=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=25.7m     Rg=4.9       Rd=550u      Rm=1m
.PARAM Inn=2.05     Unn=4.5      Rmax=70m     gmin=3.9
.PARAM act=0.361

X1      d1a      ga    sa    Tj   S3_20_s_var PARAMS: a={act} dVth={dVth1} dR={dRdson1} dgfs={dgfs1}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC1} Rm={Rm}
Rga     g1a      ga     {Rg}
Lga     gate1    g1a    {Lg*if(dgfs1==99,0,1)}
Gsa     s1a      sa     VALUE={V(s1a,sa)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsa     source1  s1a    {Ls*if(dgfs1==99,0,1)}
Rda1    d1a      d2a    {Rd}
Lda1    drain1   d2a    {Ld*if(dgfs1==99,0,1)}

X2      d1b      gb    sb    Tj   S3_20_s_var PARAMS: a={act} dVth={dVth2} dR={dRdson2} dgfs={dgfs2}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC2} Rm={Rm}
Rgb     g1b      gb     {Rg}
Lgb     gate2    g1b    {Lg*if(dgfs2==99,0,1)}
Gsb     s1b      sb     VALUE={V(s1b,sb)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsb     source2  s1b    {Ls*if(dgfs2==99,0,1)}
Rdb1    d1b      d2b    {Rd}
Ldb1    drain2   d2b    {Ld*if(dgfs2==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSL214N_L1 drain1 gate1 source1 drain2 gate2 source2
  + PARAMS: dVth1=0 dVth2=0 dRdson1=0 dRdson2=0 dgfs1=0 dgfs2=0 dC1=0 dC2=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=13.05m    Rg=11.3      Rd=550u      Rm=600u
.PARAM Inn=1.5      Unn=4.5      Rmax=140m    gmin=2.1
.PARAM act=0.122

X1      d1a      ga    sa    Tj   S3_20_s_var PARAMS: a={act} dVth={dVth1} dR={dRdson1} dgfs={dgfs1}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC1} Rm={Rm}
Rga     g1a      ga     {Rg}
Lga     gate1    g1a    {Lg*if(dgfs1==99,0,1)}
Gsa     s1a      sa     VALUE={V(s1a,sa)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsa     source1  s1a    {Ls*if(dgfs1==99,0,1)}
Rda1    d1a      d2a    {Rd}
Lda1    drain1   d2a    {Ld*if(dgfs1==99,0,1)}

X2      d1b      gb    sb    Tj   S3_20_s_var PARAMS: a={act} dVth={dVth2} dR={dRdson2} dgfs={dgfs2}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC2} Rm={Rm}
Rgb     g1b      gb     {Rg}
Lgb     gate2    g1b    {Lg*if(dgfs2==99,0,1)}
Gsb     s1b      sb     VALUE={V(s1b,sb)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsb     source2  s1b    {Ls*if(dgfs2==99,0,1)}
Rdb1    d1b      d2b    {Rd}
Ldb1    drain2   d2b    {Ld*if(dgfs2==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSS214N_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=15.03m    Rg=11.3      Rd=550u      Rm=600u
.PARAM Inn=1.5      Unn=4.5      Rmax=140m    gmin=2.1
.PARAM act=0.122

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSS214NW_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=11.28m    Rg=11.3      Rd=800u      Rm=600u
.PARAM Inn=1.5      Unn=4.5      Rmax=140m    gmin=2.1
.PARAM act=0.122

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSD214SN_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=16.37m    Rg=11.3      Rd=240u      Rm=600u
.PARAM Inn=1.5      Unn=4.5      Rmax=140m    gmin=2.1
.PARAM act=0.122

X1  d1 g s Tj S3_20_s_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSD235N_L1 drain1 gate1 source1 drain2 gate2 source2
  + PARAMS: dVth1=0 dVth2=0 dRdson1=0 dRdson2=0 dgfs1=0 dgfs2=0 dC1=0 dC2=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=46.66m    Rg=10.5      Rd=960u      Rm=2m
.PARAM Inn=0.95     Unn=4.5      Rmax=350m    gmin=1.1
.PARAM act=0.053

X1      d1a      ga    sa    Tj   S3_20_s_var PARAMS: a={act} dVth={dVth1} dR={dRdson1} dgfs={dgfs1}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC1} Rm={Rm}
Rga     g1a      ga     {Rg}
Lga     gate1    g1a    {Lg*if(dgfs1==99,0,1)}
Gsa     s1a      sa     VALUE={V(s1a,sa)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsa     source1  s1a    {Ls*if(dgfs1==99,0,1)}
Rda1    d1a      d2a    {Rd}
Lda1    drain1   d2a    {Ld*if(dgfs1==99,0,1)}

X2      d1b      gb    sb    Tj   S3_20_s_var PARAMS: a={act} dVth={dVth2} dR={dRdson2} dgfs={dgfs2}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC2} Rm={Rm}
Rgb     g1b      gb     {Rg}
Lgb     gate2    g1b    {Lg*if(dgfs2==99,0,1)}
Gsb     s1b      sb     VALUE={V(s1b,sb)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsb     source2  s1b    {Ls*if(dgfs2==99,0,1)}
Rdb1    d1b      d2b    {Rd}
Ldb1    drain2   d2b    {Ld*if(dgfs2==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSO330N02K_L1 drain1 gate1 source1 drain1a drain2 gate2 source2 drain2a
  + PARAMS: dVth1=0 dVth2=0 dRdson1=0 dRdson2=0 dgfs1=0 dgfs2=0 dC1=0 dC2=0  Ls=0 Ld=0 Lg=0

.PARAM Rs=5.31m     Rg=0.8       Rd=353u      Rm=260u
.PARAM Inn=6.6      Unn=4.5      Rmax=30m     gmin=6
.PARAM act=0.63

X1  d1a ga sa Tj1 S3_20_s_var PARAMS: a={act} dVth={dVth1} dR={dRdson1} dgfs={dgfs1} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC1} Rm={Rm} heat=0
X2  d1b gb sb Tj2 S3_20_s_var PARAMS: a={act} dVth={dVth2} dR={dRdson2} dgfs={dgfs2} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC2} Rm={Rm} heat=0
Rg1    g1a     ga    {Rg}
Lg1    gate1   g1a   {Lg*if(dgfs1==99,0,1)}
Gsa1   s1a     sa    VALUE={V(s1a,sa)/(Rs*(1+(limit(V(Tj1),-200,999)-25)*4m)-Rm)}
Rsa1   source1 sa    1Meg
Ls1    source1 s1a   {Ls*if(dgfs1==99,0,1)}
Rda1   d1a     d2a   {Rd*2}
Ld1    drain1  d2a   {Ld*2*if(dgfs1==99,0,1)}
Rdb1   d1a     d3a   {Rd*2}
Ld1a   drain1a d3a   {Ld*2*if(dgfs1==99,0,1)}

Rg2    g1b     gb    {Rg}
Lg2    gate2   g1b   {Lg*if(dgfs1==99,0,1)}
Gsa2   s1b     sb    VALUE={V(s1b,sb)/(Rs*(1+(limit(V(Tj2),-200,999)-25)*4m)-Rm)}
Rsa2   source2 sb    1Meg
Ls2    source2 s1b   {Ls*if(dgfs1==99,0,1)}
Rda2   d1b     d2b   {Rd*2}
Ld2    drain2  d2b   {Ld*2*if(dgfs1==99,0,1)}
Rdb2   d1b     d3b   {Rd*2}
Ld2a   drain2a d3b   {Ld*2*if(dgfs1==99,0,1)}

E1    Tj1     w1      VALUE={TEMP}
R1    w1       0      1u

E2    Tj2     w2      VALUE={TEMP}
R2    w2      0       1u

.ENDS

************************************************************************************************

.SUBCKT BSR802N_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=0.8n Ld=1n Lg=3n

.PARAM Rs=4.53m     Rg=2.3       Rd=500u      Rm=1m
.PARAM Inn=3.7      Unn=2.5      Rmax=23m     gmin=9.2
.PARAM act=0.991

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSL802SN_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=0.5n Ld=0.5n Lg=1n

.PARAM Rs=5.54m     Rg=2.3       Rd=206u      Rm=1m
.PARAM Inn=7.5      Unn=2.5      Rmax=22m     gmin=12.7
.PARAM act=0.991

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSL806N_L1 drain1 gate1 source1 drain2 gate2 source2
  + PARAMS: dVth1=0 dVth2=0 dRdson1=0 dRdson2=0 dgfs1=0 dgfs2=0 dC1=0 dC2=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=7.13m     Rg=4.4       Rd=550u      Rm=600u
.PARAM Inn=2.3      Unn=2.5      Rmax=57m     gmin=4.4
.PARAM act=0.361

X1      d1a      ga    sa    Tj   S3_20_u_var PARAMS: a={act} dVth={dVth1} dR={dRdson1} dgfs={dgfs1}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC1} Rm={Rm}
Rga     g1a      ga     {Rg}
Lga     gate1    g1a    {Lg*if(dgfs1==99,0,1)}
Gsa     s1a      sa     VALUE={V(s1a,sa)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsa     source1  s1a    {Ls*if(dgfs1==99,0,1)}
Rda1    d1a      d2a    {Rd}
Lda1    drain1   d2a    {Ld*if(dgfs1==99,0,1)}

X2      d1b      gb    sb    Tj   S3_20_u_var PARAMS: a={act} dVth={dVth2} dR={dRdson2} dgfs={dgfs2}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC2} Rm={Rm}
Rgb     g1b      gb     {Rg}
Lgb     gate2    g1b    {Lg*if(dgfs2==99,0,1)}
Gsb     s1b      sb     VALUE={V(s1b,sb)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsb     source2  s1b    {Ls*if(dgfs2==99,0,1)}
Rdb1    d1b      d2b    {Rd}
Ldb1    drain2   d2b    {Ld*if(dgfs2==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS
*$

**********

.SUBCKT BSS806N_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=8.11m     Rg=4.4       Rd=550u      Rm=600u
.PARAM Inn=2.3      Unn=2.5      Rmax=57m     gmin=4.4
.PARAM act=0.361

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSS806NE_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=0.5n Lg=2n

.PARAM Rs=8.11m     Rg=4.4       Rd=550u      Rm=600u
.PARAM Inn=2.3      Unn=2.5      Rmax=57m     gmin=4.4
.PARAM act=0.361

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSS816NW_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=11.28m    Rg=10        Rd=800u      Rm=600u
.PARAM Inn=1.4      Unn=2.5      Rmax=160m    gmin=2
.PARAM act=0.122

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSD816SN_L1 drain gate source PARAMS: dVth=0 dRdson=0 dgfs=0 dC=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=16.37m    Rg=10        Rd=240u      Rm=600u
.PARAM Inn=1.4      Unn=2.5      Rmax=160m    gmin=2
.PARAM act=0.122

X1  d1 g s Tj S3_20_u_var PARAMS: a={act} dVth={dVth} dR={dRdson} dgfs={dgfs} Inn={Inn} Unn={Unn}
                                        +Rmax={Rmax} gmin={gmin} Rs={Rs} Rp={Rd} dC={dC} Rm={Rm}
Rg    g1     g    {Rg}
Lg    gate   g1   {Lg*if(dgfs==99,0,1)}
Gs    s1     s    VALUE={V(s1,s)/(Rs*(1+(limit(V(Tj),-200,999)-25)*4m)-Rm)}
Rsa   s1     s    1Meg
Ls    source s1   {Ls*if(dgfs==99,0,1)}
Rda   d1     d2   {Rd}
Ld    drain  d2   {Ld*if(dgfs==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSD840N_L1 drain1 gate1 source1 drain2 gate2 source2
  + PARAMS: dVth1=0 dVth2=0 dRdson1=0 dRdson2=0 dgfs1=0 dgfs2=0 dC1=0 dC2=0 Ls=1n Ld=0.5n Lg=1n

.PARAM Rs=46.66m    Rg=10.5      Rd=960u      Rm=2m
.PARAM Inn=0.88     Unn=2.5      Rmax=400m    gmin=1
.PARAM act=0.053

X1      d1a      ga    sa    Tj   S3_20_u_var PARAMS: a={act} dVth={dVth1} dR={dRdson1} dgfs={dgfs1}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC1} Rm={Rm}
Rga     g1a      ga     {Rg}
Lga     gate1    g1a    {Lg*if(dgfs1==99,0,1)}
Gsa     s1a      sa     VALUE={V(s1a,sa)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsa     source1  s1a    {Ls*if(dgfs1==99,0,1)}
Rda1    d1a      d2a    {Rd}
Lda1    drain1   d2a    {Ld*if(dgfs1==99,0,1)}

X2      d1b      gb    sb    Tj   S3_20_u_var PARAMS: a={act} dVth={dVth2} dR={dRdson2} dgfs={dgfs2}
     + Inn={Inn} Unn={Unn} Rmax={Rmax-Rd} Rs={Rs} dC={dC2} Rm={Rm}
Rgb     g1b      gb     {Rg}
Lgb     gate2    g1b    {Lg*if(dgfs2==99,0,1)}
Gsb     s1b      sb     VALUE={V(s1b,sb)/(Rs*(1+(limit(V(Tj),-200,999)-25)*0.004)-Rm)}
Lsb     source2  s1b    {Ls*if(dgfs2==99,0,1)}
Rdb1    d1b      d2b    {Rd}
Ldb1    drain2   d2b    {Ld*if(dgfs2==99,0,1)}

E1    Tj     w      VALUE={TEMP}
R1    w      0      1u

.ENDS

**********

.SUBCKT BSC019N02KS_L0  drain  gate  source

Lg     gate  g1    3n
Ld     drain d1    1n
Ls     source s1   1n
Rs      s1    s2   482u

Rg     g1    g2     1.9
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 900  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    0.8m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=5.28n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=1996.4p  N=1.21  RS=0.58u  EG=1.12  TT=3n)
Rdiode  d1  21    0.58m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   4.19n
.MODEL     DGD    D(M=1   CJO=4.19n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    9.15n

.ENDS  BSC019N02KS_L0

******

.SUBCKT BSC026N02KS_L0  drain  gate  source

Lg     gate  g1    3n
Ld     drain d1    1n
Ls     source s1   1n
Rs      s1    s2   361u

Rg     g1    g2     1.5
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 552.4  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    1.28m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=3.24n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=1225.4p  N=1.21  RS=0.95u  EG=1.12  TT=3n)
Rdiode  d1  21    0.95m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   2.57n
.MODEL     DGD    D(M=1   CJO=2.57n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    5.62n

.ENDS  BSC026N02KS_L0

******

.SUBCKT BSC046N02KS_L0  drain  gate  source

Lg     gate  g1    3n
Ld     drain d1    1n
Ls     source s1   1n
Rs      s1    s2   254u

Rg     g1    g2     1.9
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 289.7  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    2.39m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=1.7n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=642.6p  N=1.21  RS=1.8u  EG=1.12  TT=3n)
Rdiode  d1  21    1.8m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   1.35n
.MODEL     DGD    D(M=1   CJO=1.35n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    2.95n

.ENDS  BSC046N02KS_L0

******

.SUBCKT BSR202N_L0  drain  gate  source

Lg     gate  g1    3n
Ld     drain d1    1n
Ls     source s1   0.8n
Rs      s1    s2   4.48m

Rg     g1    g2     1.9
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 80.9  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    8.88m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.47n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=179.4p  N=1.21  RS=6.46u  EG=1.12  TT=3n)
Rdiode  d1  21    6.46m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.38n
.MODEL     DGD    D(M=1   CJO=0.38n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.82n

.ENDS  BSR202N_L0

******

.SUBCKT BSL202SN_L0  drain  gate  source

Lg     gate  g1    3n
Ld     drain d1    1n
Ls     source s1   1n
Rs      s1    s2   5.48m

Rg     g1    g2     1.9
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 80.9  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    8.52m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.47n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=179.4p  N=1.21  RS=6.46u  EG=1.12  TT=3n)
Rdiode  d1  21    6.46m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.38n
.MODEL     DGD    D(M=1   CJO=0.38n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.82n

.ENDS  BSL202SN_L0

******

.SUBCKT BSL205N_L0  drain  gate  source

Lg     gate  g1    2n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   7.13m

Rg     g1    g2     4.9
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 29.5  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    23.54m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.17n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=65.3p  N=1.21  RS=17.73u  EG=1.12  TT=3n)
Rdiode  d1  21    17.73m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.14n
.MODEL     DGD    D(M=1   CJO=0.14n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.3n

.ENDS  BSL205N_L0

******

.SUBCKT BSS205N_L0  drain  gate  source

Lg     gate  g1    2n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   8.11m

Rg     g1    g2     4.9
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 29.5  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    23.54m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.17n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=65.3p  N=1.21  RS=17.73u  EG=1.12  TT=3n)
Rdiode  d1  21    17.73m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.14n
.MODEL     DGD    D(M=1   CJO=0.14n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.3n

.ENDS  BSS205N_L0

******

.SUBCKT BSL207N_L0  drain  gate  source

Lg     gate  g1    2n
Ld     drain d1    0.5n
Ls     source s1   1.5n
Rs      s1    s2   25.7m

Rg     g1    g2     4.9
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 29.5  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    23.54m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.17n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=65.3p  N=1.21  RS=17.73u  EG=1.12  TT=3n)
Rdiode  d1  21    17.73m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.14n
.MODEL     DGD    D(M=1   CJO=0.14n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.3n

.ENDS  BSL207N_L0

******

.SUBCKT BSL214N_L0  drain  gate  source

Lg     gate  g1    2n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   13.05m

Rg     g1    g2     11.3
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 10  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    68.58m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.06n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=22.1p  N=1.21  RS=52.46u  EG=1.12  TT=3n)
Rdiode  d1  21    52.46m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.05n
.MODEL     DGD    D(M=1   CJO=0.05n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.1n

.ENDS  BSL214N_L0

******

.SUBCKT BSS214N_L0  drain  gate  source

Lg     gate  g1    2n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   15.03m

Rg     g1    g2     11.3
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 10  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    68.58m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.06n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=22.1p  N=1.21  RS=52.46u  EG=1.12  TT=3n)
Rdiode  d1  21    52.46m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.05n
.MODEL     DGD    D(M=1   CJO=0.05n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.1n

.ENDS  BSS214N_L0

******

.SUBCKT BSS214NW_L0  drain  gate  source

Lg     gate  g1    1n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   11.28m

Rg     g1    g2     11.3
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 10  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    68.83m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.06n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=22.1p  N=1.21  RS=52.46u  EG=1.12  TT=3n)
Rdiode  d1  21    52.46m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.05n
.MODEL     DGD    D(M=1   CJO=0.05n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.1n

.ENDS  BSS214NW_L0

******

.SUBCKT BSD214SN_L0  drain  gate  source

Lg     gate  g1    1n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   16.37m

Rg     g1    g2     11.3
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 10  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    68.27m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.06n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=22.1p  N=1.21  RS=52.46u  EG=1.12  TT=3n)
Rdiode  d1  21    52.46m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.05n
.MODEL     DGD    D(M=1   CJO=0.05n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.1n

.ENDS  BSD214SN_L0

******

.SUBCKT BSD235N_L0  drain  gate  source

Lg     gate  g1    1n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   46.66m

Rg     g1    g2     10.5
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 4.3  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    157.56m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.03n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=9.6p  N=1.21  RS=120.75u  EG=1.12  TT=3n)
Rdiode  d1  21    120.75m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.025n
.MODEL     DGD    D(M=1   CJO=0.02n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.045n

.ENDS  BSD235N_L0

******

.SUBCKT BSO330N02K_L0  drain  gate  source

Lg     gate  g1    3n
Ld     drain d1    1.5n
Ls     source s1   1.9n
Rs      s1    s2   5.31m

Rg     g1    g2     0.8
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 51.4  VTO=1.61  THETA=0  VMAX=1.5e5  ETA=0.01  LEVEL=3)
Rd     d1    d2    13.53m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.3n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=114p  N=1.21  RS=10.16u  EG=1.12  TT=3n)
Rdiode  d1  21    10.16m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.24n
.MODEL     DGD    D(M=1   CJO=0.24n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.52n

.ENDS  BSO330N02K_L0

******

.SUBCKT BSR802N_L0  drain  gate  source

Lg     gate  g1    3n
Ld     drain d1    1n
Ls     source s1   0.8n
Rs      s1    s2   4.53m

Rg     g1    g2     2.3
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 139.7  VTO=1.17  THETA=0  VMAX=1.5e5  ETA=0.003  LEVEL=3)
Rd     d1    d2    6.96m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.47n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=179.4p  N=1.21  RS=6.46u  EG=1.12  TT=3n)
Rdiode  d1  21    6.46m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.69n
.MODEL     DGD    D(M=1.1   CJO=0.69n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.96n

.ENDS  BSR802N_L0

******

.SUBCKT BSL802SN_L0  drain  gate  source

Lg     gate  g1    1n
Ld     drain d1    0.5n
Ls     source s1   0.5n
Rs      s1    s2   5.54m

Rg     g1    g2     2.3
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 139.7  VTO=1.17  THETA=0  VMAX=1.5e5  ETA=0.003  LEVEL=3)
Rd     d1    d2    6.66m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.47n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=179.4p  N=1.21  RS=6.46u  EG=1.12  TT=3n)
Rdiode  d1  21    6.46m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.69n
.MODEL     DGD    D(M=1.1   CJO=0.69n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.96n

.ENDS  BSL802SN_L0

******

.SUBCKT BSL806N_L0  drain  gate  source

Lg     gate  g1    2n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   7.13m

Rg     g1    g2     4.4
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 50.9  VTO=1.17  THETA=0  VMAX=1.5e5  ETA=0.003  LEVEL=3)
Rd     d1    d2    18.28m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.17n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=65.3p  N=1.21  RS=17.73u  EG=1.12  TT=3n)
Rdiode  d1  21    17.73m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.25n
.MODEL     DGD    D(M=1.1   CJO=0.25n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.35n

.ENDS  BSL806N_L0

******

.SUBCKT BSS806N_L0  drain  gate  source

Lg     gate  g1    2n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   8.11m

Rg     g1    g2     4.4
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 50.9  VTO=1.17  THETA=0  VMAX=1.5e5  ETA=0.003  LEVEL=3)
Rd     d1    d2    18.28m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.17n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=65.3p  N=1.21  RS=17.73u  EG=1.12  TT=3n)
Rdiode  d1  21    17.73m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.25n
.MODEL     DGD    D(M=1.1   CJO=0.25n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.35n

.ENDS  BSS806N_L0

******

.SUBCKT BSS806NE_L0  drain  gate  source

Lg     gate  g1    2n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   8.11m

Rg     g1    g2     4.4
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 50.9  VTO=1.17  THETA=0  VMAX=1.5e5  ETA=0.003  LEVEL=3)
Rd     d1    d2    18.28m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.17n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=65.3p  N=1.21  RS=17.73u  EG=1.12  TT=3n)
Rdiode  d1  21    17.73m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.25n
.MODEL     DGD    D(M=1.1   CJO=0.25n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.35n

.ENDS  BSS806NE_L0

******

.SUBCKT BSS816NW_L0  drain  gate  source

Lg     gate  g1    1n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   11.28m

Rg     g1    g2     10
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 17.2  VTO=1.17  THETA=0  VMAX=1.5e5  ETA=0.003  LEVEL=3)
Rd     d1    d2    53.26m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.06n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=22.1p  N=1.21  RS=52.46u  EG=1.12  TT=3n)
Rdiode  d1  21    52.46m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.09n
.MODEL     DGD    D(M=1.1   CJO=0.09n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.12n

.ENDS  BSS816NW_L0

******

.SUBCKT BSD816SN_L0  drain  gate  source

Lg     gate  g1    1n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   16.37m

Rg     g1    g2     10
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 17.2  VTO=1.17  THETA=0  VMAX=1.5e5  ETA=0.003  LEVEL=3)
Rd     d1    d2    52.7m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.06n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=22.1p  N=1.21  RS=52.46u  EG=1.12  TT=3n)
Rdiode  d1  21    52.46m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.09n
.MODEL     DGD    D(M=1.1   CJO=0.09n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.12n

.ENDS  BSD816SN_L0

******

.SUBCKT BSD840N_L0  drain  gate  source

Lg     gate  g1    1n
Ld     drain d1    0.5n
Ls     source s1   1n
Rs      s1    s2   46.66m

Rg     g1    g2     10.5
M1      d2    g2    s2    s2    DMOS    L=1u   W=1u
.MODEL DMOS NMOS ( KP= 7.5  VTO=1.17  THETA=0  VMAX=1.5e5  ETA=0.003  LEVEL=3)
Rd     d1    d2    121.71m TC=6.5m

Dbd     s2    d2    Dbt
.MODEL     Dbt    D(BV=24   M=0.35  CJO=0.03n  VJ=0.7V)
Dbody   s2   21    DBODY
.MODEL DBODY  D(IS=9.6p  N=1.21  RS=120.75u  EG=1.12  TT=3n)
Rdiode  d1  21    120.75m TC=7m

.MODEL   sw    NMOS(VTO=0  KP=10   LEVEL=1)
Maux      g2   c    a    a   sw
Maux2     b    d    g2    g2   sw
Eaux      c    a    d2    g2   1
Eaux2     d    g2   d2    g2   -1
Cox       b    d2   0.04n
.MODEL     DGD    D(M=1.1   CJO=0.04n   VJ=0.5)
Rpar      b    d2   1Meg
Dgd       a    d2   DGD
Rpar2     d2   a    10Meg
Cgs     g2    s2    0.05n

.ENDS  BSD840N_L0

******

*^^^^^^^^  End of included SPICE model from OptiMOS2_20V.lib ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from BAS40.cir vvvvvvvv
*
*******************************************
*
*BAS40-06
*
*NXP Semiconductors
*
*General-purpose Schottky diodes
*
*
*
*
*IFSM = 200mA @ tp = 10ms
*VF   = 1V    @ IF = 40mA
*
*
*
*
*
*
*
*
*
*
*Package pinning does not match Spice model pinning.
*Package: SOT23
*
*Package Pin 1: Cathode                  D1
*Package Pin 2: Cathode                  D2
*Package Pin 3: Anode;Anode              D1;D2
*
*
*
*Simulator: PSPICE
*
*******************************************
*#
.SUBCKT BAS40 1 2
*
* The Resistors do not
* reflect physical devices.
* Instead they improve modeling
* in the reverse mode of
* operation.
*
R1 1 2 6.659E+08
D1 1 2 BAS40
*
.MODEL BAS40 D(
+ IS = 1.419E-08
+ N = 1.025
+ BV = 44
+ IBV = 1.255E-07
+ RS = 4.942
+ CJO = 4.046E-12
+ VJ = 0.323
+ M = 0.4154
+ FC = 0.5
+ TT = 0
+ EG = 0.69
+ XTI = 2)
.ENDS
*

*^^^^^^^^  End of included SPICE model from BAS40.cir ^^^^^^^^
*
*vvvvvvvv  Included SPICE model from PDTA114EU.cir vvvvvvvv
*
**********************************************************
*
* PDTA114EU
*
* NXP Semiconductors
*
* Resistor Equipped PNP Transistor (RET)
* IC   = 100 mA
* VCEO = 50 V
* hFE  = min. 5 @ 5V/5mA
* R1   = 10 Kohm
* R2   = 10 Kohm
*
*
* Package pinning does not match Spice model pinning.
* Package: SOT 323
*
* Package Pin 1: Base
* Package Pin 2: Emitter
* Package Pin 3: Collector
*
*
* Extraction date (week/year): 43/2014
* Simulator: Spice 3
*
**********************************************************
*sb#
* Please note: ---Resistances R1 and R2 are not part of the
* model and have to be added separately.---
* Diode D is dedicated to improve modeling in  reverse
* area of operation and does not reflect a physical device.
*
.SUBCKT PDTA114EU 1 4 3
*
Q1 1 2 3 MAIN
D1 1 2 DIODE
R1 4 2 10K
R2 2 3 10K
.MODEL MAIN PNP
+ IS = 1.656E-014
+ NF = 0.9954
+ ISE = 5.941E-015
+ NE = 1.6
+ BF = 319.1
+ IKF = 0.04633
+ VAF = 7.981
+ NR = 0.9949
+ ISC = 1E-018
+ NC = 0.9168
+ BR = 12.77
+ IKR = 0.05607
+ VAR = 24.01
+ RB = 39.4
+ IRB = 0.0001259
+ RBM = 3.4
+ RE = 0.3
+ RC = 0.3184
+ XTB = 0
+ EG = 1.11
+ XTI = 3
+ CJE = 9.067E-012
+ VJE = 0.712
+ MJE = 0.3653
+ TF = 9.5E-010
+ XTF = 18
+ VTF = 3
+ ITF = 0.7
+ PTF = 0
+ CJC = 8.778E-012
+ VJC = 0.9955
+ MJC = 0.6991
+ XCJC = 1
+ TR = 3.4E-008
+ CJS = 0
+ VJS = 0.75
+ MJS = 0.333
+ FC = 0.79
.MODEL DIODE D
+ IS = 5.358E-015
+ N = 1.066
+ BV = 1000
+ IBV = 0.001
+ RS = 1E+004
+ CJO = 0
+ VJ = 1
+ M = 0.5
+ FC = 0
+ TT = 0
+ EG = 1.11
+ XTI = 3
.ENDS
*^^^^^^^^  End of included SPICE model from PDTA114EU.cir ^^^^^^^^
*
*==============  Begin SPICE netlist of main design ============
Y2 7 0 3 0 pcb_mod len=0.03
Rpu pullup 3 22k
XTpu pullup #ctrl_pu VCC_MEM PDTA114EU
XFB1 7 8 BLM18KG260TN1
RX2 8 0 1meg
Y1 8 0 2 0 pcb_mod len=0.03
C10 0 mem_pin 15p
RX1 mem_pin 0 1meg
C20 0 fpga_pin 15p
.OPTIONS ABSTOL=1nA CHGTOL=1pC ITL1=150 ITL2=150 ITL4=500 RELTOL=0.005

.CONTROL
  OP
  TRAN 1ns 270ns
  PLOT V(CLK) V(FPGA_PIN) V(MEM_PIN)
  MEAS tran tdiff TRIG v(clk_a) VAL=0.5 RISE=1 TARG v(mem_pin) VAL=2.97 RISE=1
  MEAS tran tdiff TRIG v(clk_a) VAL=0.5 FALL=1 TARG v(mem_pin) VAL=0.33 FALL=1

  MEAS tran tdiff TRIG v(clk_a) VAL=0.5 RISE=1 TARG v(fpga_pin) VAL=2.97 RISE=1
  MEAS tran tdiff TRIG v(clk_a) VAL=0.5 FALL=1 TARG v(fpga_pin) VAL=0.33 FALL=1
.ENDC

XP1 mem_pin 0 6 S25FL032P
Y3 mem_pin 0 7 0 pcb_mod len=0.04
XB1 6 unconnected_pin-6 VCC_MEM 0 VCC_MEM 0 low clk unconnected_pin-5 unconnected_pin-4 F_SO spec=0 start_on=1
XP2 fpga_pin 0 5 Cyclone
XB2 5 unconnected_pin-3 VCC_FPGA_IO 0 VCC_FPGA_IO 0 high clk unconnected_pin-2 unconnected_pin-1 1c_cmos33_io_d8 spec=-1 start_on=1
.lib cyclone.lib Cyclone
.lib cyclone.lib 1c_cmos33_io_d8
.lib m69a.lib MT29F2G08ABAEAWP
.lib m69a.lib DQ_FULL_33
.lib s25fl032p_n_i_33_r1.lib S25FL032P
.lib s25fl032p_n_i_33_r1.lib F_SO
.lib murata_bead_subckts.lib murata_bead_subckts

.model pullup d_pullup(load=0)
.model pulldown d_pulldown(load=0)
A_pulldown low pulldown
A_pullup high pullup

.model clock d_osc(rise_delay=1f fall_delay=1f cntl_array=[0 1] freq_array=[12Meg 12Meg])
A_clk 0 clk clock
.model dac1 dac_bridge (t_rise=1p t_fall=1p)
A_clk_a [clk] [clk_a] dac1

* https://technick.net/tools/impedance-calculator/microstrip/
* 0.8mm width, 35um thickness on 1.5mm pcb stripline model
.model pcb_mod txl C=58.22p L=516.5n R=0.607 G=0 length=1
XD6 0 fpga_pin BAS40
XT4 3 gate_vcc 4 BSS214N_L0
XT3 VCC_MEM gate_vcc 4 BSS214N_L0
XT6 3 gate_gnd 0 BSS214N_L0
R5 0 gate_vcc 47k
XT7 gate_gnd 0 0 PDTA114EU
XT5 gate_vcc 0 0 PDTA114EU
XT2 gate_vpp ctrl_vpp 0 PDTC114EU
XD4 ctrl_vpp 0 BAS40
V4 V_USB 0 DC 5V
V3 VCC_FPGA_IO 0 DC 3.3
V2 VCC_MEM 0 DC 3.3
V1 VPP_MEM 0 DC 9V
XD5 fpga_pin VCC_FPGA_IO BAV70LT1G
XT1 3 gate_vpp VPP_MEM BSS83P_L0
R6 gate_gnd 0 22k
R4 ctrl_vpp 0 33k
R8 2 fpga_pin 2.2k
C1 2 1 2.2n
R1 gate_vpp VPP_MEM 22k
R9 1 fpga_pin 15
.end
